# Allegro board S32K148EVB_Q144_RevA_Layout.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PTA18/FTM4_CH0/LPUART1_TX/LPSPI: length 14.8
  TOP w0.16: U8.1 v1(79.3,68.04)
  L3_INT_1 w0.191: 79.79,69.05 82.33,71.58 82.33,75.51 v1(81.8,76.03)
  L3_INT_1 w0.203: 79.79,69.05 79.3,68.55 v1(79.3,68.04)
  L6_INT_2 w0.191: J6.16 79.78,76.36 80.46,76.36 80.78,76.03 v1(81.8,76.03)
PTA19/FTM4_CH1/LPUART1_RX/LPSPI: length 12.1
  TOP w0.16: U8.2 v1(78.8,67.57)
  L3_INT_1 w0.191: 78.8,69.05 81.24,71.49 J6.13
  L3_INT_1 w0.203: 78.8,69.05 v1(78.8,67.57)
PTA20/FTM4_CH2/LPSPI1_SIN: length 18.1
  TOP w0.16: U8.3 v1(78.3,68.04)
  L3_INT_1 w0.191: 77.97,69.05 77.88,69.13 77.88,72.01 80.68,74.81 80.68,76.17 80.13,76.71 80.13,81.4 J6.15
  L3_INT_1 w0.203: 77.97,69.05 78.3,68.71 v1(78.3,68.04)
PTA21/FTM4_CH3/FXIO_D0/LPSPI1_P: length 21.1
  TOP w0.16: U8.6 v1(76.8,67.57)
  L3_INT_1 w0.191: J6.12 82.65,81.37 82.65,70.71 81.01,69.07 80.8,69.07 80.77,69.05
  L3_INT_1 w0.203: 80.77,69.05 80.1,68.37 80.1,68.16 79.03,67.09 77.28,67.09 v1(76.8,67.57)
PTA22/FTM4_CH4/FXIO_D1/LPSPI1_P: length 25.5
  TOP w0.16: U8.9 v1(75.3,68.04)
  L3_INT_1 w0.191: 81.49,69.05 85.48,73.04 85.48,76.7 85.21,76.97 85.21,81.4 J6.9
  L3_INT_1 w0.203: 81.49,69.05 81.16,68.72 80.95,68.72 80.45,68.23 80.45,68.01 79.18,66.74 75.95,66.74 75.3,67.39 v1(75.3,68.04)
PTA23/FTM4_CH6/FXIO_D2: length 29
  TOP w0.16: U8.13 v1(73.3,68.04)
  L3_INT_1 w0.191: 81.99,69.05 87.43,74.49 87.43,81.08 J6.6
  L3_INT_1 w0.203: 81.99,69.05 81.31,68.36 81.09,68.36 80.81,68.08 80.81,67.87 79.33,66.38 74.31,66.38 73.3,67.39 v1(73.3,68.04)
PTA24/FTM4_CH7/FXIO_D3: length 31.9
  TOP w0.16: U8.16 v1(71.79,67.57)
  L3_INT_1 w0.191: J6.3 90.29,81.4 90.29,75.28 86.11,71.1 86,71.1 85.72,70.82 85.72,70.71 83.93,68.92
  L3_INT_1 w0.203: 83.93,68.92 81.04,66.03 73.34,66.03 v1(71.79,67.57)
PTA25/FTM5_CH0: length 81.2
  TOP w0.16: U7.10 v1(72.79,63.24) ; U8.17 v1(71.29,68.04)
  L6_INT_2 w0.191: v1(40.12,62.82) 39.18,62.82 37.71,61.36 37.71,55.27 40.53,52.45 v1(40.53,51.62) ; J2.2 40.52,78.87 40.52,76.97 41.18,76.32 42.94,76.32 51.68,67.58 52.74,67.58
  L6_INT_2 w0.203: 52.74,67.58 53.21,67.12 55.94,67.12 56.32,66.74 70.64,66.74 71.29,67.39 v1(71.29,68.04)
  BOTTOM w0.16: v1(72.79,63.24) 72.79,64.32 71.78,65.33 71.78,65.58 71.29,66.07 v1(71.29,68.04)
  BOTTOM w0.406: R552.1 v1(40.53,51.62) ; J2.2 42.84,78.75 42.84,76.43 41.03,74.63 41.03,63.74 v1(40.12,62.82)
PTA26/FTM5_CH1/LPSPI1_PCS0: length 144.7
  TOP w0.16: U8.26 v1(66.79,67.57) ; U7.19 v1(68.29,62.77)
  TOP w0.406: v1(57.65,20.03) 57.65,21.24 56.83,22.06 R283.1
  L3_INT_1 w0.191: v1(26.48,32.15) 26.48,42.42 26.83,42.76 26.83,43.16 26.48,43.51 26.48,45.6 26.08,46 26.08,46.08 v1(25.74,46.42) ; v1(68.29,62.77) 69.66,61.4 73.8,61.4 79.65,55.56 79.65,54.08 81.26,52.47 81.26,42.76 83.34,40.68 83.34,38.14 81.65,36.44 81.65,34.29 80.4,33.04 v1(80.4,32.7)
  L6_INT_2 w0.191: v1(57.65,20.03) 57.21,20.46 39.64,20.46 39.08,19.9 28.35,19.9 26.48,21.77 v1(26.48,32.15)
  BOTTOM w0.16: v1(68.29,62.77) 68.29,64.73 66.79,66.23 v1(66.79,67.57)
  BOTTOM w0.191: v1(57.65,20.03) 72.15,20.03 77.48,25.36 77.48,29.78 v1(80.4,32.7)
  BOTTOM w0.203: R564.1 26.05,46.64 25.82,46.42 v1(25.74,46.42)
PTA26/FTM5_CH1/LPSPI1_PCS0_LS: length 9.8
  TOP w0.406: v1(29.81,56.59) R149.1
  TOP w0.508: TP17.1 29.49,56.86 29.73,56.61 29.78,56.61 v1(29.81,56.59)
  BOTTOM w0.203: v1(29.81,56.59) 29.81,53.48 27.62,51.29 27.01,51.29 26.56,50.84 U507.6
PTA27/FTM5_CH2/LPSPI1_SOUT/LP_1: length 6
  TOP w0.406: v1(32.4,55.1) 32.37,55.1 32.37,55.08 31.89,54.6 TP22.1 30.47,54.6 R154.1
  BOTTOM w0.203: v1(32.4,55.1) 32.4,54.26 33.29,53.37 U506.6
PTA27/FTM5_CH2/LPSPI1_SOUT/LPUA: length 93.6
  TOP w0.16: U7.22 v1(66.79,63.24) ; U8.29 v1(65.29,68.04)
  L3_INT_1 w0.191: v1(46.77,58.02) 46.55,58.02 42.05,53.52 40.85,53.52 39.3,51.97 39.3,51.3 37.42,49.42 35.78,49.42 35.21,48.85 v1(34.73,48.85)
  L6_INT_2 w0.191: v1(46.77,58.02) 48.59,58.02 52.27,61.71 52.74,61.71 ; J4.6 51.87,25.52 49.1,25.52 47.97,26.65 47.97,28.43 45.81,30.6 35.92,30.6 33.01,33.51 32.56,33.51 30.7,35.38 29.14,36.93 29.14,42.97 34.4,48.23 34.4,48.52 v1(34.73,48.85)
  L6_INT_2 w0.203: 52.74,61.71 54.2,61.71 54.45,61.45 59.19,61.45 59.36,61.62 60.38,61.62 60.85,61.15 65.35,61.15 66.79,62.59 v1(66.79,63.24)
  BOTTOM w0.16: v1(66.79,63.24) 66.79,64.7 65.29,66.2 v1(65.29,68.04)
  BOTTOM w0.203: v1(34.73,48.85) R555.1
PTA28/FTM5_CH3/LPSPI1_SCK/LPU_1: length 10.3
  TOP w0.406: R150.1 29.91,54.82 30.57,55.48 v1(30.57,55.89) 30.92,55.89 31.15,56.12 TP21.1
  BOTTOM w0.203: U507.7 26.96,50.7 27.18,50.91 27.83,50.91 30.23,53.31 30.23,55.55 v1(30.57,55.89)
PTA28/FTM5_CH3/LPSPI1_SCK/LPUAR: length 126.8
  TOP w0.16: U7.24 v1(65.79,63.24) ; U8.31 v1(64.29,68.04)
  L6_INT_2 w0.191: J4.9 54.11,22.36 43.32,22.36 42.03,23.65 42.03,26.75 40.83,27.95 35.19,27.95 34.41,28.73 34.41,31.15 32.69,32.87 32.31,32.87 30.43,34.74 27.41,37.76 v1(27.41,42.24) 27.41,43.18 27.72,43.48 28.75,43.48 32.09,46.82 32.09,52.07 30.53,53.63 29.13,53.63 27.22,55.54 27.22,56.93 29.58,59.29 30.65,59.29 32.31,57.63 33.53,57.63 39.2,63.31 41.19,63.31 41.31,63.19 50.68,63.19 v1(51.09,63.6) ; v1(51.17,71) 52.83,69.34 54.51,69.34 54.72,69.12 57.13,69.12 57.79,69.78 61.19,69.78 61.58,69.4 62.94,69.4 v1(64.29,68.04)
  BOTTOM w0.16: v1(64.29,68.04) 64.29,66.25 65.79,64.75 v1(65.79,63.24)
  BOTTOM w0.191: v1(51.09,63.6) 51.62,64.13 51.62,70.55 v1(51.17,71)
  BOTTOM w0.406: v1(27.41,42.24) 27.41,44.2 27.52,44.31 R563.1
PTA29/FTM5_CH4/LPUART2_TX/LPS_1: length 113.2
  TOP w0.16: U7.26 v1(64.79,63.24) ; U8.33 v1(63.29,68.04)
  L3_INT_1 w0.191: v1(36.32,51.34) 36.66,51.68 36.66,53.25 36.09,53.83 36.09,54.69 36.37,54.97 37.71,54.97 37.86,54.82 38.65,54.82 39.16,55.33 41.61,55.33 46.29,60.01 v1(51.24,60.01)
  L6_INT_2 w0.191: 61.48,69.05 61.06,69.47 57.97,69.47 57.55,69.05 ; J4.12 57.28,25.19 55.39,25.19 54.73,24.53 54.73,23.52 53.89,22.67 45.54,22.67 44.25,23.96 44.25,29.61 43.58,30.28 35.73,30.28 32.82,33.2 32.43,33.2 30.57,35.06 28.82,36.8 28.82,43.1 33.95,48.23 33.95,48.97 v1(36.32,51.34) ; v1(51.14,70.14) 52.29,68.99 52.74,68.99
  L6_INT_2 w0.203: 57.55,69.05 57.25,68.74 54.61,68.74 54.36,68.99 52.74,68.99 ; v1(63.29,68.04) 62.28,69.05 61.48,69.05
  BOTTOM w0.16: v1(64.79,63.24) 64.79,64.79 63.29,66.29 v1(63.29,68.04)
  BOTTOM w0.203: v1(36.32,51.34) 36.54,51.34 36.54,51.24 36.74,51.04 R554.1
  BOTTOM w0.406: v1(51.14,70.14) 51.14,66.04 50.51,65.4 50.51,61.33 51.24,60.59 v1(51.24,60.01)
PTA29/FTM5_CH4/LPUART2_TX/LPSPI: length 5.4
  TOP w0.406: v1(33.69,53.73) 31.61,53.73 31.43,53.55 TP25.1 30.49,53.17 30.06,53.17 R177.1
  BOTTOM w0.203: U506.7 v1(33.69,53.73)
PTA30/FTM5_CH5: length 54.6
  TOP w0.16: U8.34 v1(62.79,67.57) ; U7.27 v1(64.29,62.77)
  L3_INT_1 w0.191: 62.79,69.05 62.79,70.79 64.89,72.89 64.89,82.65 63.92,83.62 45,83.62 v1(43.69,82.31)
  L3_INT_1 w0.203: v1(62.79,67.57) 62.79,69.05
  L6_INT_2 w0.191: J2.4 40.19,78.54 40.19,80.11 41.16,81.08 42.08,81.08 42.24,80.92 43.21,80.92 43.69,81.39 v1(43.69,82.31)
  BOTTOM w0.16: v1(64.29,62.77) 64.29,64.81 62.79,66.32 v1(62.79,67.57)
PTA31/FTM5_CH6: length 40.1
  TOP w0.16: U8.40 v1(59.79,67.57) ; U7.33 v1(61.29,62.77)
  L3_INT_1 w0.191: 55.97,71.82 53.43,74.36 50.7,74.36 49.65,75.4 49.65,80.56 48.81,81.4 45.01,81.4 v1(44.33,82.07)
  L3_INT_1 w0.203: v1(59.79,67.57) 59.79,70.26 58.23,71.82 55.97,71.82
  L6_INT_2 w0.191: v1(44.33,82.07) 44.33,80.14 J2.1
  BOTTOM w0.16: v1(61.29,62.77) 61.29,64.49 59.79,65.99 v1(59.79,67.57)
PTB0/SBC_LPSPI0_PCS0: length 92
  TOP w0.16: U7.78 v1(62.29,44.59)
  TOP w0.203: v1(61.8,39.78) 61.79,39.8 61.79,40.98
  BOTTOM w0.16: v1(61.8,39.78) 61.8,40.26 62.29,40.75 v1(62.29,44.59)
  BOTTOM w0.191: J2.7 37.64,78.53 37.64,82.96 36.69,83.91 26.22,83.91 24.96,82.65 24.96,71.53 39.33,57.16 39.46,57.16 46.44,50.18 46.44,48.83 46.84,48.43 46.84,46.88 52.72,41.01 54.22,41.01 57.11,38.11 59.77,38.11 59.78,38.12 60.7,38.12 60.71,38.11 60.75,38.11 61.79,39.15 61.79,39.3 61.8,39.31 v1(61.8,39.78)
PTB1/LPSPI0_SOUT: length 67.2
  TOP w0.16: v1(61.29,39.32) 61.29,39.78 61.29,39.79 61.29,40.98 ; U7.77 v1(61.79,44.12)
  L3_INT_1 w0.191: 52.74,69.05 51.56,69.05 43.12,77.49 43.12,80.02 42.07,81.07 36.08,81.07 35.11,80.09 35.11,78.54 J2.10
  L3_INT_1 w0.203: v1(61.79,44.12) 61.31,43.64 59.09,43.64 58.15,44.58 58.15,65.1 55.77,67.47 54.43,67.47 52.85,69.05 52.74,69.05
  BOTTOM w0.16: v1(61.79,44.12) 61.79,40.83 61.29,40.33 v1(61.29,39.32)
PTB2/LPSPI0_SCK: length 76.1
  TOP w0.16: U7.68 v1(58.98,46.93) ; U8.78 v1(54.65,47.93)
  L6_INT_2 w0.191: v1(38.98,74.93) 38.5,74.93 38.44,74.99 31.36,74.99 J2.16
  BOTTOM w0.16: v1(54.65,47.93) 57.99,47.93 v1(58.98,46.93)
  BOTTOM w0.191: v1(54.65,47.93) 54.01,47.93 52.95,48.99 52.95,52.33 50.36,54.93 50.36,60.36 49.75,60.96 49.75,65.88 50.34,66.46 50.34,73.4 51.76,74.83 51.76,75.45 51.36,75.85 50.32,75.85 49.33,76.84 49.33,82.97 48.68,83.62 41.16,83.62 40.51,82.97 40.51,76.65 39.31,75.46 39.31,75.27 v1(38.98,74.93)
PTB3/LPSPI0_SIN: length 72.4
  TOP w0.16: U7.63 v1(59.45,49.43) ; U8.73 v1(54.18,50.43)
  L6_INT_2 w0.191: v1(38.44,75.47) 38.11,75.8 33.08,75.8 J2.13
  BOTTOM w0.16: v1(59.45,49.43) 56.54,49.43 55.54,50.43 v1(54.18,50.43)
  BOTTOM w0.191: v1(38.44,75.47) 38.78,75.8 39.12,75.8 40.19,76.87 40.19,83.1 41.03,83.94 48.81,83.94 49.65,83.1 49.65,76.97 50.45,76.17 51.49,76.17 52.11,75.56 52.11,74.56
  BOTTOM w0.203: 52.11,74.56 50.66,73.11 50.66,66.33 50.08,65.74 50.08,61.1 50.68,60.5 50.68,55.14 53.33,52.48 53.33,51.09 53.99,50.43 v1(54.18,50.43)
PTB4/MII_RMII_MDIO: length 104
  TOP w0.406: R46.2 103.71,73.62 103.31,73.23 v1(103.29,73.23) ; R268.2 v1(39.18,32.56)
  L6_INT_2 w0.191: v1(103.29,73.23) 103.77,73.23 107.89,69.1 107.89,56.66 102.17,50.93 100.09,50.93 99.63,50.47 99.63,45.6 85.25,31.22 78.39,31.22 78.14,31.47 60.54,31.47 60.46,31.55 57.16,31.55 56.95,31.76 51.49,31.76 51.09,31.36 39.9,31.36 39.18,32.08 v1(39.18,32.56)
PTB4/MII_RMII_MDIO/QSPI_B_IO0: length 49.5
  TOP w0.16: U7.41 v1(59.45,60.43) ; U8.49 v1(54.18,62.44)
  TOP w0.406: v1(34.89,42.27) 36.03,42.27 36.06,42.25 R227.1
  L3_INT_1 w0.191: 52.74,62.44 43.38,62.44 39.17,58.23 36.35,58.23 34.99,56.88 34.99,54.02 35.78,53.23 35.78,52.24 33.79,50.25 33.79,42.9 34.41,42.27 v1(34.89,42.27)
  L3_INT_1 w0.203: v1(54.18,62.44) 52.74,62.44
  BOTTOM w0.16: v1(59.45,60.43) 57.44,60.43 55.44,62.44 v1(54.18,62.44)
PTB4/MII_RMII_MDIO/QSPI_B_IO0_1: length 4.1
  TOP w0.279: R268.1 38.7,34.81 v1(38.7,35.41) 38.7,35.93 38.84,36.07 38.84,36.08 38.84,36.08 U14.2
  BOTTOM w0.279: R268.1 38.7,34.81 v1(38.7,35.41)
PTB4/MII_RMII_MDIO/QSPI_B_IO0__: length 3.3
  TOP w0.279: v1(37.98,41.39) 38.35,41.02 38.39,41.02 38.84,40.57 U14.13
  TOP w0.406: v1(37.98,41.39) 37.96,41.39 38.04,41.46 R227.2
  BOTTOM w0.279: v1(37.98,41.39) 37.96,41.39 38.04,41.47 38.04,41.85 R572.2
PTB5/ENET_MII_RMII_MDC: length 104.9
  TOP w0.279: U22.2 65.75,34.52 65.76,34.5 65.76,33.98 66,33.74 v1(66.52,33.74) R273.2
  TOP w0.406: R38.2 103.52,74.64 102.6,73.72 v1(102.6,73.14)
  L6_INT_2 w0.191: v1(66.52,33.74) 68.52,33.74 68.99,34.22 78.8,34.22 79.32,33.7 79.71,33.7 80.81,34.8 83.44,34.8 83.45,34.8 84.11,34.8 84.39,35.08 84.39,35.74 91.47,42.82 91.47,46.55 92.72,47.81 92.72,47.83 98.52,53.62 100.17,53.62 101.01,54.46 101.01,54.59 104.06,57.64 104.06,60.77 102.51,62.32 102.51,64.01 103.16,64.66 103.16,67.78 102.6,68.34 102.6,68.5 102.51,68.59 101.64,68.59 101.55,68.68 101.55,68.81 101.64,68.91 102.51,68.91 102.6,69 102.6,69.13 102.51,69.23 101.64,69.23 101.55,69.32 101.55,69.45 101.64,69.54 102.51,69.54 102.6,69.64 102.6,69.77 102.51,69.86 101.64,69.86 101.55,69.95 101.55,70.08 101.64,70.18 102.51,70.18 102.6,70.27 102.6,70.59 102.51,70.68 101.22,70.68 101.13,70.59 101.13,70.13 101.04,70.04 100.91,70.04 100.81,70.13 100.81,70.59 100.72,70.68 100.59,70.68 100.5,70.59 100.5,70.13 100.4,70.04 100.27,70.04 100.18,70.13 100.18,70.59 100.09,70.68 99.95,70.68 99.86,70.59 99.86,70.13 99.77,70.04 99.64,70.04 99.54,70.13 99.54,70.59 99.45,70.68 98.68,70.68 98.59,70.77 98.59,70.91 98.68,71 99.41,71 99.51,71.09 99.51,71.88 99.6,71.97 99.73,71.97 99.82,71.88 99.82,71.09 99.92,71 100.99,71 101.08,71.09 101.08,71.41 100.99,71.5 100.33,71.5 100.23,71.6 100.23,71.73 100.33,71.82 100.99,71.82 101.08,71.91 101.08,72.04 100.99,72.14 100.33,72.14 100.23,72.23 100.23,72.36 100.33,72.45 100.99,72.45 101.08,72.55 101.08,73.25 101.17,73.34 101.31,73.34 101.4,73.25 101.4,71.09 101.49,71 101.62,71 101.72,71.09 101.72,73.25 101.81,73.34 101.94,73.34 102.03,73.25 102.03,71.09 102.13,71 102.51,71 102.6,71.09 102.6,71.3 102.7,71.4 103.04,71.4 103.13,71.49 103.13,71.62 103.04,71.71 102.7,71.71 102.6,71.81 102.6,71.94 102.7,72.03 103.04,72.03 103.13,72.12 103.13,72.26 103.04,72.35 102.7,72.35 102.6,72.44 v1(102.6,73.14)
PTB5/MII_RMII_MDC: length 89.2
  TOP w0.16: U7.40 v1(58.98,60.93) ; U8.48 v1(54.65,62.94)
  L3_INT_1 w0.191: v1(54.65,62.94) 54.65,63.06 54.15,63.56 51.74,63.56 v1(51.09,62.91)
  L6_INT_2 w0.191: v1(58.64,32.37) 57.52,32.37 57.12,32.77 56.7,32.77 56.01,32.08 51.36,32.08 50.96,31.68 40.4,31.68 39.66,32.43 39.66,32.76 39.38,33.04 36.63,33.04 35.18,34.49 32.48,34.49 29.78,37.2 29.78,41.11 35.36,46.7 38.73,46.7 40.77,48.73 40.77,50.1 41,50.33 41,52.43 39.68,53.75 39.68,54.89 39.4,55.17 39.38,55.17 38.63,55.92 38.63,60.75 40.14,62.27 50.44,62.27 v1(51.09,62.91)
  BOTTOM w0.16: v1(54.65,62.94) 55.41,62.94 57.42,60.93 v1(58.98,60.93)
  BOTTOM w0.406: R604.1 v1(58.64,32.37)
PTB5/MII_RMII_MDC__A: length 3.6
  TOP w0.279: v1(60.6,33.93) 60.6,34.1 60.83,34.34 60.83,34.43 60.92,34.52 U22.13
  BOTTOM w0.406: R603.2 60.99,33.54 v1(60.6,33.93) 60.19,33.93 R604.2
PTB6_XTAL: length 16.5
  TOP w0.16: U8.25 v1(67.29,68.04) ; U7.18 v1(68.79,63.24)
  TOP w0.229: R76.1 66,70.06 66.26,70.32 R64.2 ; R64.2 67.02,70.51 66.53,71 Y1.2 C3.1 ; R64.2 R76.2 67.02,68.32 v1(67.29,68.04)
  BOTTOM w0.16: v1(67.29,68.04) 67.29,66.23 68.79,64.73 v1(68.79,63.24)
PTB7_EXTAL: length 17.2
  TOP w0.16: U7.17 v1(69.29,62.77) ; U8.24 v1(67.79,67.57)
  TOP w0.229: R78.1 69.05,69.96 68.69,70.32 R64.1 ; R64.1 68.53,70.81 Y1.1 C4.1 ; R64.1 R78.2 68.03,68.74 67.79,68.5 v1(67.79,67.57)
  BOTTOM w0.16: v1(67.79,67.57) 67.79,66.29 69.29,64.79 v1(69.29,62.77)
PTB8/FTM3_CH0/SAI1_BCLK: length 64.7
  TOP w0.16: U8.136 v1(82.91,44.42) ; U7.111 v1(78.1,45.93)
  TOP w0.406: R318.1 55.31,13.65 63.18,13.65 J5.4
  L3_INT_1 w0.203: J5.4 74.94,27.85 73.36,27.85 72.5,28.71 72.5,29.63 77.51,34.64 78.6,34.64 79.07,35.11 79.07,37.69 80.57,39.19 80.57,40.18 78.96,41.8 78.96,45.56 78.58,45.93 v1(78.1,45.93)
  BOTTOM w0.16: v1(82.91,44.42) 80.72,44.42 79.21,45.93 v1(78.1,45.93)
PTB9/FTM3_CH1/LPI2C0_SCLS: length 107.4
  TOP w0.16: v1(82.8,42.9) 82.33,42.9 82.31,42.92 U8.133 ; U7.109 v1(78.1,44.93)
  TOP w0.203: v1(82.8,42.9) 83.52,42.9 83.55,42.92 83.93,42.92
  TOP w0.406: R192.1 v1(89.73,50.12) 89.73,45.17 89.01,44.46 86.3,44.46 84.76,42.92 83.93,42.92 ; R319.1 v1(55.59,12.35)
  L3_INT_1 w0.191: v1(55.59,12.35) 56.05,11.9 62.1,11.9 75.29,25.08 76.18,25.08 77.27,26.17 77.27,27.22 78.11,28.06 79.16,28.06 79.81,28.71 79.81,29.93 84.84,34.95 84.84,36.62 84.35,37.12 84.35,37.72 84.51,37.88 84.51,42.03 83.93,42.61
  L3_INT_1 w0.203: 83.93,42.61 83.64,42.9 v1(82.8,42.9)
  L6_INT_2 w0.191: J6.10 85.81,75.4 v1(91.22,75.4)
  BOTTOM w0.16: v1(78.1,44.93) 80.21,42.82 82.25,42.82 82.33,42.9 v1(82.8,42.9)
  BOTTOM w0.406: v1(91.22,75.4) 90.51,74.69 90.51,53.07 89.17,51.73 89.17,50.68 v1(89.73,50.12)
PTB10/FTM3_CH2/LPI2C0_SDAS: length 153.7
  TOP w0.16: v1(77.48,44.16) 77.46,44.16 77.46,44.16 77.29,43.99 U7.108 ; 78.8,40.98 v1(78.8,39.32)
  TOP w0.406: R187.1 v1(89.75,51.14) ; R315.1 v1(45.43,12.35)
  L3_INT_1 w0.191: v1(45.43,12.35) 45.76,12.02 49.13,12.02 49.94,12.83 52.32,12.83 53.57,11.58 63.7,11.58 64.93,12.81 66.82,12.81 67.77,11.85 81.19,11.85 90.28,20.95 90.28,28.56 90.29,28.58 90.29,29.76 90.28,29.77 90.28,50.61 v1(89.75,51.14)
  L6_INT_2 w0.191: 83.93,39.99 85.29,39.99 89.21,43.9 89.21,47.44 90.2,48.43 90.2,50.69 v1(89.75,51.14)
  L6_INT_2 w0.203: 83.93,39.99 80.68,39.99 79.67,38.98 79.14,38.98 v1(78.8,39.32)
  BOTTOM w0.16: v1(78.8,39.32) 78.8,42.83 v1(77.48,44.16)
  BOTTOM w0.406: v1(89.75,51.14) 91.73,53.12 91.73,70.95 92.62,71.84 92.62,80.47 91.91,81.19 85.82,81.19 85.1,80.47 85.1,78.65 J6.7
PTB11/FTM3_CH3/LPI2C0_HREQ: length 86.8
  TOP w0.16: 77.3,40.98 v1(77.3,39.79) ; U7.107 v1(76.79,44.12)
  L3_INT_1 w0.191: J2.17 27.82,78.87 27.82,76.97 31.56,73.24 45.11,73.24 52.69,65.66 52.74,65.66
  L3_INT_1 w0.203: 52.74,65.66 55.07,65.66 56.37,64.36 56.37,43.85 58.35,41.86 74.53,41.86 v1(76.79,44.12)
  BOTTOM w0.16: v1(76.79,44.12) 77.3,43.62 v1(77.3,39.79)
PTB12/FTM0_CH0/FTM3_FLT2/CAN2_R: length 95.5
  TOP w0.16: U7.98 v1(72.29,44.59) ; 72.8,40.98 v1(72.8,39.32)
  L3_INT_1 w0.191: J2.29 20.17,78.55 26.52,78.55 27.8,79.84 27.8,80.41 28.46,81.07 29.37,81.07 30.35,80.09 30.35,76.99 33.76,73.57 45.23,73.57 51.94,66.86 52.74,66.86
  L3_INT_1 w0.203: 52.74,66.86 53.59,66.02 55.21,66.02 56.72,64.51 56.72,43.99 58.5,42.22 70.57,42.22 72.29,43.94 v1(72.29,44.59)
  BOTTOM w0.16: v1(72.8,39.32) 72.8,40.41 72.29,40.91 v1(72.29,44.59)
PTB13/FTM0_CH1/FTM3_FLT1/CAN2_T: length 81.9
  TOP w0.16: 72.29,40.98 v1(72.29,39.79) ; U7.97 v1(71.79,44.12)
  BOTTOM w0.16: 71.79,40.29 v1(72.29,39.79)
  BOTTOM w0.191: 54.08,40.65 56.94,37.79 59.9,37.79 59.91,37.8 60.57,37.8 60.96,37.41 62.76,37.41 63.05,37.11 64.94,37.11 66,38.17 71.41,38.17 72.29,39.06 v1(72.29,39.79) ; J2.26 22.41,78.86 22.41,75.1 23.18,74.32 23.18,72.86 39.2,56.84 39.31,56.84 46.11,50.04 46.11,48.7 46.52,48.29
  BOTTOM w0.203: v1(71.79,44.12) 71.79,40.29 ; 54.08,40.65 52.59,40.65 46.52,46.72 46.52,48.29
PTB14/FTM0_CH2/LPSPI1_SCK/ADC1_: length 32.6
  TOP w0.16: 71.29,40.98 v1(71.29,39.79) ; U7.96 v1(71.29,44.59)
  TOP w0.203: v1(71.29,39.79) 71.29,39.05 71.73,38.62 73.27,38.62
  TOP w0.406: 73.27,38.62 75.86,36.03 80.17,36.03 83.64,32.55 88.02,32.55 J5.15
  BOTTOM w0.16: v1(71.29,44.59) 71.29,40.25 71.29,40.25 v1(71.29,39.79)
PTB15/FTM0_CH3/LPSPI1_SIN/ADC1_: length 37.2
  TOP w0.16: U7.95 v1(70.79,44.12) ; 70.79,40.98 v1(70.79,39.32)
  TOP w0.203: 71.01,38.62 70.79,38.83 v1(70.79,39.32)
  TOP w0.406: J5.17 92.7,27.93 88.4,27.93 88.37,27.95 88.36,27.95 87.64,28.66 87.64,28.68 87.59,28.73 87.59,30.26 86.53,31.33 78.3,31.33 71.01,38.62
  BOTTOM w0.16: v1(70.79,39.32) 70.79,39.78 70.79,39.78 v1(70.79,44.12)
PTB16/FTM0_CH4/LPSPI1_SOUT/ADC1: length 40.5
  TOP w0.16: U7.94 v1(70.29,44.59) ; 70.29,40.98 v1(70.29,39.79)
  TOP w0.203: v1(81.8,38.82) 81.88,38.75 81.88,38.62
  TOP w0.406: 81.88,38.62 81.88,35.73 84.5,33.11 89.07,33.11 90.29,31.89 93.76,31.89 J5.19
  L6_INT_2 w0.203: v1(81.8,38.82) 81.6,38.62 70.81,38.62 70.29,39.14 v1(70.29,39.79)
  BOTTOM w0.16: v1(70.29,39.79) 70.29,40.25 70.29,40.25 v1(70.29,44.59)
PTB17/FTM0_CH5/LPSPI1_PCS3/FTM5: length 116.9
  TOP w0.16: 69.29,40.98 v1(69.29,39.32) ; U7.93 v1(69.79,44.12)
  TOP w0.406: v1(69.38,30.92) 69.79,30.51 69.79,22.95 65.87,19.04 v1(65.29,19.04) ; R287.1 v1(48.81,19.72)
  L3_INT_1 w0.191: J2.14 32.57,78.86 32.57,77.3 35.97,73.9 45.35,73.9 51.87,67.38 52.74,67.38 ; v1(69.38,30.92) 69.38,34.77 70.03,35.42 70.03,37.95 69.37,38.62
  L3_INT_1 w0.203: v1(69.29,39.32) 69.29,38.69 69.37,38.62 ; v1(69.79,44.12) 68.24,42.57 58.65,42.57 57.08,44.14 57.08,64.66 55.36,66.37 53.75,66.37 52.74,67.38
  L6_INT_2 w0.191: v1(65.29,19.04) 57.09,19.04 56.06,20.06 49.14,20.06 v1(48.81,19.72)
  BOTTOM w0.16: v1(69.29,39.32) 69.79,39.82 v1(69.79,44.12)
PTB18/FTM5_CH7/LPSPI1_PCS1/ADC0: length 50.3
  TOP w0.16: v1(58.94,68.67) 58.46,68.19 58.33,68.19 58.31,68.16 58.31,68.01 58.28,67.98 U8.43 ; U7.36 v1(59.79,63.24)
  L3_INT_1 w0.191: 58.94,69.05 58.94,70.32 57.77,71.49 55.83,71.49 55.65,71.68 55.65,71.69 53.34,74 50.6,74 49.33,75.27 49.33,80.43 48.68,81.08 44.25,81.08 42.73,82.6 42.73,82.97 42.08,83.62 33.54,83.62 32.89,82.97 32.89,81.08 J2.11
  L3_INT_1 w0.203: 58.94,69.05 v1(58.94,68.67)
  BOTTOM w0.16: v1(59.79,63.24) 58.31,64.72 58.31,68.16 58.33,68.19 58.46,68.19 v1(58.94,68.67)
PTB19/FTM5_CH7: length 27.8
  TOP w0.16: v1(57.85,68.16) 57.85,67.7 57.78,67.63 U8.44
  BOTTOM w0.203: v1(57.85,68.16) 57.85,68.64 57.86,68.66 57.86,68.77 58.15,69.05
  BOTTOM w0.406: 58.15,69.05 58.32,69.23 58.46,69.23 67.02,77.78 67.02,82.71 68.04,83.73 72.4,83.73 J6.24
PTB20/FTM6_CH0/ADC0_SE17: length 103.9
  TOP w0.16: U8.45 54.78,64.44 54.73,64.48 v1(53.96,64.48) ; v1(59.62,62.26) 59.45,62.43 U7.37
  TOP w0.406: v1(57.87,33.3) 57.87,33.94 R265.1
  L3_INT_1 w0.191: 55.29,54.1 55.29,47.89 54.85,47.45 54.5,47.45 52.93,45.88 52.93,45.44 53.6,44.77 53.6,43.21 53.94,42.87 53.94,42.07 51.63,39.76 51.63,38.31 53.76,36.18 53.76,36.01 56.81,32.97 57.54,32.97 v1(57.87,33.3)
  L3_INT_1 w0.203: 55.29,54.1 55.29,63.95 54.76,64.48 v1(53.96,64.48)
  L6_INT_2 w0.191: v1(66.03,80.5) 66.03,81.7 68.19,83.86 89.4,83.86 90.13,83.12 90.13,78.7 J6.1
  BOTTOM w0.16: v1(59.62,62.26) 57.4,64.48 v1(53.96,64.48)
  BOTTOM w0.203: 57.3,69.05 55.61,67.37 55.61,66.13 v1(53.96,64.48)
  BOTTOM w0.406: 57.3,69.05 66.03,77.78 v1(66.03,80.5)
PTB20/FTM6_CH0/ADC0_SE17__A: length 3.7
  TOP w0.279: U22.12 60.6,35.02 60.31,34.73 v1(60.31,34.55)
  TOP w0.406: R265.2 60.06,34.48 60.13,34.55 v1(60.31,34.55)
  BOTTOM w0.406: v1(60.31,34.55) 60.82,34.55 60.9,34.48 R597.2
PTB20/FTM6_CH0/ENET_INT: length 104.9
  TOP w0.279: R263.2 66.9,34.76 66.8,34.66 66.72,34.66 66.46,34.4 66.46,34.42 v1(66.46,34.42) 65.86,35.02 U22.3
  TOP w0.406: R5.2 102.88,77.68 102.31,77.11 v1(102.31,76.44)
  L6_INT_2 w0.191: v1(102.31,76.44) 99.92,74.05 99.33,74.05 99.23,73.96 99.23,73.42 99.14,73.33 99.01,73.33 98.92,73.42 98.92,73.96 98.82,74.05 98.45,74.05 97.81,73.41 97.81,73.28 98.44,72.65 98.44,72.52 98.35,72.43 98.22,72.43 97.59,73.06 97.45,73.06 97.36,72.96 97.36,72.83 97.99,72.2 97.99,72.07 97.9,71.98 97.77,71.98 97.14,72.61 97.01,72.61 96.91,72.51 96.91,72.38 97.54,71.75 97.54,71.62 97.45,71.53 97.32,71.53 96.69,72.16 96.56,72.16 95.68,71.28 95.68,70.13 98.63,67.18 98.95,67.18 99.04,67.27 99.04,67.97 98.95,68.07 98.38,68.07 98.29,68.16 98.29,68.29 98.38,68.38 98.95,68.38 99.04,68.48 99.04,69.01 99.13,69.1 99.26,69.1 99.36,69.01 99.36,67.27 99.45,67.18 99.58,67.18 99.67,67.27 99.67,69.01 99.77,69.1 99.9,69.1 99.99,69.01 99.99,67.27 100.08,67.18 100.22,67.18 100.31,67.27 100.31,69.01 100.4,69.1 100.53,69.1 100.63,69.01 100.63,68.27 100.72,68.18 102.13,68.18 102.22,68.09 102.22,67.96 102.13,67.86 100.72,67.86 100.63,67.77 100.63,67.27 100.72,67.18 101.78,67.18 102.48,66.48 102.48,65.62 102.19,65.33 102.19,62.16 103.75,60.61 103.75,57.77 100.69,54.72 100.69,54.59 100.04,53.94 98.39,53.94 92.41,47.96 92.41,47.94 91.15,46.69 91.15,43.15 85.05,37.05 84.02,37.05 83.95,37.11 83.3,37.11 82.56,36.37 82.28,36.37 81.34,35.43 80.32,35.43 79.54,34.65 68.84,34.65 68.61,34.42 v1(66.46,34.42)
PTB21/FTM6_CH1/ADC0_SE18: length 49.4
  TOP w0.16: v1(54.57,63.99) 54.62,63.99 54.62,63.99 54.68,63.94 U8.46 ; U7.38 v1(58.98,61.93)
  L3_INT_1 w0.191: J6.4 88.86,74.34 85.94,71.42 85.87,71.42 85.4,70.95 85.4,70.88 81.05,66.53 v1(80.3,66.53)
  L6_INT_2 w0.203: v1(54.57,63.99) 54.78,64.2 77.18,64.2 79.52,66.53 v1(80.3,66.53)
  BOTTOM w0.16: v1(58.98,61.93) 56.93,63.99 v1(54.57,63.99)
PTB22/FTM6_CH2/MII_CRS/LPUART1_: length 55.3
  TOP w0.16: U8.66 v1(54.65,53.93) ; U7.58 v1(58.98,51.93)
  L3_INT_1 w0.191: J3.5 31.87,28.06 43.58,28.06 44.46,28.94 44.46,32.13 47.28,34.95 47.28,36.73 46.74,37.27 46.74,38.84 45.66,39.92 45.66,43.47 47.56,45.36 47.56,50.73 50.76,53.93 v1(54.65,53.93)
  BOTTOM w0.16: v1(54.65,53.93) 55.43,53.93 57.43,51.93 v1(58.98,51.93)
PTB23/FTM6_CH3/LPUART1_RX/MII_C: length 59.3
  TOP w0.16: U8.68 v1(54.65,52.93) ; U7.60 v1(58.98,50.93)
  TOP w0.406: v1(47.28,27.98) 46.21,27.98 46.19,27.95 29.22,27.95 J3.2
  L3_INT_1 w0.191: v1(47.28,27.98) 47.37,28.06 47.37,33.04 48.71,34.38 48.71,35.14 47.97,35.88 47.97,36.93 47.37,37.53 47.37,39.11 46.92,39.56 46.92,40.62 48.26,41.96 48.26,50.53 50.66,52.93 v1(54.65,52.93)
  BOTTOM w0.16: v1(54.65,52.93) 55.32,52.93 57.32,50.93 v1(58.98,50.93)
PTB24/FTM6_CH4: length 38.3
  TOP w0.16: U8.69 v1(54.18,52.43)
  BOTTOM w0.203: v1(54.18,52.43) 54.18,52.73 52.26,54.65 52.26,63.64 52.39,63.76 52.39,67.81 52.39,68.1 52.39,68.1 52.44,68.15 52.44,73.2 54.42,75.18 54.42,82.97 53.76,83.63 51.88,83.63 J1.18
PTB25/FTM6_CH5/LPSPI2_PCS0/ADC0: length 124.2
  TOP w0.16: U8.71 v1(54.18,51.43) ; U7.62 v1(58.98,49.93)
  TOP w0.406: R218.1 v1(99.4,41.74) ; v1(40.6,21.26) 40.6,21.84 41.87,23.11 41.87,25.36 J3.17
  L3_INT_1 w0.191: J3.17 41.7,27.73 46.54,27.73 46.77,27.5 47.48,27.5 47.76,27.78 47.76,32.98 49.03,34.25 49.03,35.27 48.29,36.01 48.29,37.06 47.69,37.66 47.69,39.24 47.24,39.69 47.24,40.45 48.58,41.79 48.58,45.98 52.74,50.15
  L3_INT_1 w0.203: v1(54.18,51.43) 53.46,50.71 53.3,50.71 52.74,50.15
  L6_INT_2 w0.191: v1(40.6,21.26) 88.85,21.26 92.65,25.05 92.65,34.99 v1(99.4,41.74)
  BOTTOM w0.16: v1(58.98,49.93) 56.8,49.93 55.3,51.43 v1(54.18,51.43)
PTB26/FTM6_CH6: length 35.1
  TOP w0.16: U8.72 v1(54.65,50.93)
  BOTTOM w0.203: J1.15 52.18,81.39 52.18,76.49 52.44,76.24 52.44,73.95 52.11,73.62 52.11,68.29 52.06,68.24 52.06,63.94 51.93,63.81 51.93,63.77 51.93,63.5 51.93,63.5 51.93,54.47 53.69,52.71 53.69,51.24 54,50.93 v1(54.65,50.93)
PTB27/FTM6_CH7/LPSPI2_SOUT/ADC0: length 135.9
  TOP w0.16: U8.74 v1(54.65,49.93) ; U7.64 v1(58.98,48.93)
  TOP w0.406: R221.1 v1(102.45,41.74)
  L3_INT_1 w0.191: 50.99,41.68 50.99,33.61 49.35,31.97 49.35,25.26 47.93,23.84 47.93,23.5 47.33,22.9 37.7,22.9 36.79,23.81 36.79,25.36 J3.11
  L3_INT_1 w0.203: v1(54.65,49.93) 54.22,49.5 54.22,49.37 53.7,48.85 53.7,47.72 53.78,47.63 53.78,47.23 52.57,46.01 52.57,45.31 53.25,44.62 53.25,43.94 50.99,41.68
  L6_INT_2 w0.191: v1(102.45,41.74) 102.45,41.85 101.76,42.54 99.34,42.54 99.34,42.54 99.07,42.54 90.15,33.62 89.97,33.43 89.97,31.85 87.75,29.63 87.75,23.05 86.73,22.04 41.1,22.04 39.49,23.65 39.49,24.66 38.64,25.52 36.63,25.52 J3.11
  BOTTOM w0.16: v1(58.98,48.93) 56.53,48.93 55.53,49.93 v1(54.65,49.93)
PTB28/FTM7_CH0/LPSPI2_SIN/ADC0_: length 148.3
  TOP w0.16: U8.75 54.33,49.43 54.19,49.57 v1(53.73,49.57) ; U7.65 v1(59.45,48.43)
  TOP w0.406: v1(100.42,50.14) R183.1 ; v1(38.93,21.24) 38.34,21.24 36.84,22.74 36.84,25.41 J3.14
  L3_INT_1 w0.191: J3.14 39.16,25.53 46.14,25.53 48.08,27.47 48.08,32.84 49.4,34.17 49.4,36.42 48.38,37.44 48.38,40.46 49.23,41.31 49.23,45.06 52.74,48.58
  L3_INT_1 w0.203: 52.74,48.58 v1(53.73,49.57)
  L6_INT_2 w0.191: v1(38.93,21.24) 39.4,21.24 39.87,20.78 57.34,20.78 57.41,20.71 98.74,20.71 104.96,26.93 104.96,44.25 104.9,44.31 104.9,44.71 104.96,44.77 104.96,45.6 v1(100.42,50.14)
  BOTTOM w0.16: v1(53.73,49.57) 54.19,49.57 54.33,49.43 55.4,49.43 56.39,48.43 v1(59.45,48.43)
PTB29/FTM7_CH1/LPSPI2_SCK/ADC0_: length 152
  TOP w0.16: U7.69 v1(59.45,46.43) ; U8.79 54.28,47.43 54.28,47.43 v1(53.3,47.43)
  TOP w0.406: v1(101.83,50.15) 101.43,50.54 R184.1
  L3_INT_1 w0.191: 52.74,46.87 49.54,43.67 49.54,41.17 49.33,40.97 49.33,37.25 49.72,36.86 49.72,34.02 48.39,32.69 48.39,27.34 46.27,25.21 37.92,25.21 36.82,26.32 36.82,26.89 35.98,27.73 34.08,27.73 J3.8
  L3_INT_1 w0.203: 52.74,46.87 v1(53.3,47.43)
  L6_INT_2 w0.191: J3.8 34.41,25.2 38.5,25.2 39.17,24.53 39.17,23.52 40.97,21.72 83.58,21.72 83.59,21.72 88.25,21.72 90.28,23.76 90.28,33.3 99.21,42.22 101.63,42.22 101.97,41.88 101.97,41.55 102.25,41.27 102.65,41.27 103.16,41.77 103.16,46.8 102.27,47.69 102.2,47.69 99.94,49.94 99.94,50.33 100.22,50.61 101.36,50.61 v1(101.83,50.15)
  BOTTOM w0.16: v1(59.45,46.43) 57.5,46.43 56.5,47.43 v1(53.3,47.43)
PTB30/FTM7_CH2: length 48.4
  TOP w0.16: U8.80 v1(54.65,46.93)
  L3_INT_1 w0.191: J1.6 59.58,81.16 59.58,77.05 58.84,76.31 52.35,76.31 v1(51.29,75.25)
  BOTTOM w0.191: v1(54.65,46.93) 53.13,46.93 52.57,47.49 52.57,50.8 52.57,50.8 52.57,51.99 52.57,51.99 52.57,52.12 50.02,54.67 50.02,59.61 49.43,60.2 49.43,66.07 50,66.64 50,73.96 v1(51.29,75.25)
PTB31/FTM7_CH3: length 53.3
  TOP w0.16: U8.82 v1(54.65,45.92)
  L3_INT_1 w0.191: J1.3 62.14,81.19 62.14,77.08 59.27,74.2 54.03,74.2 53.56,74.67 51.05,74.67 v1(50.45,75.28)
  BOTTOM w0.191: v1(54.65,45.92) 54.01,45.92 53.35,46.58 52.99,46.58 50.58,48.99 50.58,49.82 49.7,50.7 49.7,59.48 49.12,60.07 49.12,66.2 49.68,66.77 49.68,74.51 v1(50.45,75.28)
PTC0/MII_RMII_RXD1: length 103.4
  TOP w0.406: R277.2 v1(56.92,32.29) ; R63.2 v1(103.61,70.57)
  L6_INT_2 w0.191: v1(56.92,32.29) 57.35,31.87 60.59,31.87 60.67,31.79 79.27,31.79 79.52,31.54 85.11,31.54 99.31,45.73 99.31,50.6 99.96,51.25 102.03,51.25 107.58,56.79 107.58,62.16 107.48,62.25 106.46,62.25 106.36,62.35 106.36,62.48 106.46,62.57 107.48,62.57 107.58,62.66 107.58,62.8 107.48,62.89 106.46,62.89 106.36,62.98 106.36,63.11 106.46,63.21 107.48,63.21 107.58,63.3 107.58,63.43 107.48,63.52 106.46,63.52 106.36,63.62 106.36,63.75 106.46,63.84 107.48,63.84 107.58,63.93 107.58,66.6 106.24,67.94 106.24,68.07 107.29,69.12 107.29,69.25 107.2,69.34 107.07,69.34 106.02,68.29 105.89,68.29 105.79,68.39 105.79,68.52 106.84,69.57 106.84,69.7 106.75,69.79 106.62,69.79 105.57,68.74 105.44,68.74 105.34,68.83 105.34,68.97 106.39,70.02 106.39,70.15 106.3,70.24 106.17,70.24 105.12,69.19 104.99,69.19 104.89,69.28 104.89,69.41 105.95,70.47 105.95,70.6 105.85,70.69 105.72,70.69 104.67,69.64 104.54,69.64 104.45,69.73 104.45,69.86 105.5,70.91 105.5,71.05 105.4,71.14 105.27,71.14 104.22,70.09 104.09,70.09 v1(103.61,70.57)
PTC0/MII_RMII_RXD1/QSPI_B_RWD_1: length 4.2
  TOP w0.229: 48.09,35.65 48.09,34.99 47.91,34.81 v1(47.92,34.81) 48.57,34.81 49.18,35.41 U16.13
  BOTTOM w0.229: 48.09,35.65 48.09,34.99 47.91,34.81 v1(47.92,34.81)
PTC0/MII_RMII_RXD1/QSPI_B_RWDS: length 43.7
  TOP w0.16: U7.53 v1(59.45,54.43) ; U8.61 v1(54.18,56.43)
  TOP w0.406: R259.1 v1(45.68,35.65)
  L3_INT_1 w0.191: 52.74,55.87 47.85,55.87 45.42,53.43 44.37,53.43 42.04,51.1 42.04,48.71 41.28,47.95 41.28,42.28 41.78,41.79 41.78,41.11 41.15,40.49 41.15,39.43 42.58,38 43.33,38 v1(45.68,35.65)
  L3_INT_1 w0.203: v1(54.18,56.43) 53.61,55.87 52.74,55.87
  BOTTOM w0.16: v1(59.45,54.43) 57.76,54.43 55.76,56.43 v1(54.18,56.43)
PTC0/MII_RMII_RXD1/QSPI_B_RWDS_: length 4.7
  TOP w0.279: U16.2 54.12,35.41 54.32,35.21 v1(54.32,34.61)
  TOP w0.406: v1(54.32,34.61) 54.73,34.2 54.74,34.2 55.17,33.77 55.71,33.77 R277.1
  BOTTOM w0.406: R598.2 54.3,34.63 v1(54.32,34.61)
PTC1/MII_RMII_RXD0: length 104.6
  TOP w0.406: R74.2 v1(103.19,69.56) ; v1(57.21,33.56) 57.14,33.56 56.6,34.1 R264.2
  L6_INT_2 w0.191: v1(103.19,69.56) 105.02,67.73 105.02,67.19 104.92,67.1 103.57,67.1 103.47,67.01 103.47,66.87 103.57,66.78 104.92,66.78 105.02,66.69 105.02,66.56 104.92,66.46 103.57,66.46 103.47,66.37 103.47,66.24 103.57,66.15 104.92,66.15 105.02,66.05 105.02,65.92 104.92,65.83 103.57,65.83 103.47,65.74 103.47,65.6 103.57,65.51 104.92,65.51 105.02,65.42 105.02,65.29 104.92,65.19 103.57,65.19 103.47,65.1 103.47,64.97 103.57,64.88 104.92,64.88 105.02,64.78 105.02,64.65 104.92,64.56 103.57,64.56 103.47,64.47 103.47,64.33 103.57,64.24 104.92,64.24 105.02,64.15 105.02,61.8 105.11,61.7 107.11,61.7 107.2,61.61 107.2,61.48 107.11,61.39 105.11,61.39 105.02,61.29 105.02,61.16 105.11,61.07 107.11,61.07 107.2,60.98 107.2,60.84 107.11,60.75 105.11,60.75 105.02,60.66 105.02,60.53 105.11,60.43 107.11,60.43 107.2,60.34 107.2,60.21 107.11,60.12 105.11,60.12 105.02,60.02 105.02,57.25 101.96,54.19 101.96,54.07 100.13,52.23 98.47,52.23 93.68,47.43 93.68,47.42 92.42,46.16 92.42,40.79 83.8,32.17 79.78,32.17 79.53,32.43 60.93,32.43 60.86,32.5 60.23,32.5 58.95,33.78 57.43,33.78 v1(57.21,33.56)
PTC1/MII_RMII_RXD0/QSPI_B_SCK: length 45.8
  TOP w0.16: U7.52 v1(58.98,54.93) ; U8.60 v1(54.65,56.93)
  TOP w0.406: R253.1 46.57,36.66 v1(46.16,36.26)
  L3_INT_1 w0.191: v1(46.16,36.26) 46.16,35.46 45.88,35.17 45.42,35.17 42.91,37.68 42.45,37.68 40.84,39.3 40.84,40.63 41.46,41.25 41.46,41.65 40.5,42.61 40.5,47.83 39.8,48.53 39.8,49.75 46.96,56.91 52.72,56.91 52.74,56.93
  L3_INT_1 w0.203: 52.74,56.93 v1(54.65,56.93)
  BOTTOM w0.16: v1(54.65,56.93) 55.76,56.93 57.77,54.93 v1(58.98,54.93)
PTC1/MII_RMII_RXD0/QSPI_B_SCK_1: length 3.3
  TOP w0.229: 48.09,36.66 48.34,36.66 v1(48.93,36.07) 49.09,35.91 U16.12
  BOTTOM w0.229: 48.09,36.66 48.34,36.66 v1(48.93,36.07)
PTC1/MII_RMII_RXD0/QSPI_B_SCK__: length 4.4
  TOP w0.279: U16.3 54.54,35.91 v1(54.78,35.67) 54.78,35.44 R264.1
  BOTTOM w0.279: v1(54.78,35.67) 54.78,34.99 55.13,34.63 R264.1
PTC2/MII_RMII_TXD0: length 103.8
  TOP w0.406: v1(57.67,34.59) 57.25,35 57.25,35 R260.2 ; R102.2 103.49,64.22 103.04,63.76 103.04,63.82 v1(102.98,63.82)
  L6_INT_2 w0.191: v1(57.67,34.59) 59.25,34.59 60.7,33.14 61.12,33.14 61.2,33.06 61.64,33.06 61.74,33.16 61.74,33.68 61.83,33.77 61.96,33.77 62.05,33.68 62.05,33.16 62.15,33.06 62.28,33.06 62.37,33.16 62.37,33.68 62.46,33.77 62.59,33.77 62.69,33.68 62.69,33.16 62.78,33.06 67.57,33.06 67.66,33.16 67.66,33.33 67.75,33.42 67.89,33.42 67.98,33.33 67.98,33.16 68.07,33.06 68.2,33.06 68.3,33.16 68.3,33.33 68.39,33.42 68.52,33.42 68.61,33.33 68.61,33.16 68.71,33.06 68.84,33.06 68.93,33.16 68.93,33.33 69.02,33.42 69.16,33.42 69.25,33.33 69.25,33.16 69.34,33.06 70.88,33.06 70.97,33.16 70.97,33.81 71.06,33.9 71.19,33.9 71.29,33.81 71.29,33.16 71.38,33.06 71.51,33.06 71.6,33.16 71.6,33.81 71.7,33.9 71.83,33.9 71.92,33.81 71.92,33.16 72.02,33.06 72.15,33.06 72.24,33.16 72.24,33.81 72.33,33.9 72.46,33.9 72.56,33.81 72.56,33.16 72.65,33.06 72.78,33.06 72.87,33.16 72.87,33.81 72.97,33.9 73.1,33.9 73.19,33.81 73.19,33.16 73.29,33.06 73.42,33.06 73.51,33.16 73.51,33.81 73.6,33.9 73.73,33.9 73.83,33.81 73.83,33.16 73.92,33.06 74.05,33.06 74.14,33.16 74.14,33.81 74.24,33.9 74.37,33.9 74.46,33.81 74.46,33.16 74.56,33.06 74.69,33.06 74.78,33.16 74.78,33.81 74.87,33.9 75,33.9 75.1,33.81 75.1,33.16 75.19,33.06 75.32,33.06 75.41,33.16 75.41,33.81 75.51,33.9 75.64,33.9 75.73,33.81 75.73,33.16 75.83,33.06 75.96,33.06 76.05,33.16 76.05,33.81 76.14,33.9 76.27,33.9 76.37,33.81 76.37,33.16 76.46,33.06 76.59,33.06 76.68,33.16 76.68,33.81 76.78,33.9 76.91,33.9 77,33.81 77,33.16 77.1,33.06 77.23,33.06 77.32,33.16 77.32,33.81 77.41,33.9 77.54,33.9 77.64,33.81 77.64,33.16 77.73,33.06 77.86,33.06 77.95,33.16 77.95,33.81 78.05,33.9 78.18,33.9 78.27,33.81 78.27,33.16 78.37,33.06 79.53,33.06 80.56,34.1 81.12,34.1 81.22,34.19 81.22,34.38 81.31,34.48 81.44,34.48 81.54,34.38 81.54,34.19 81.63,34.1 81.76,34.1 81.85,34.19 81.85,34.38 81.95,34.48 82.08,34.48 82.17,34.38 82.17,34.19 82.26,34.1 82.39,34.1 82.49,34.19 82.49,34.38 82.58,34.48 82.71,34.48 82.81,34.38 82.81,34.19 82.9,34.1 83.03,34.1 83.12,34.19 83.12,34.38 83.22,34.48 83.35,34.48 83.44,34.38 83.44,34.19 83.53,34.1 83.85,34.1 85.03,35.28 85.03,35.41 84.83,35.61 84.83,35.74 84.93,35.83 85.06,35.83 85.26,35.64 85.39,35.64 85.48,35.73 85.48,35.86 85.28,36.06 85.28,36.19 85.38,36.28 85.51,36.28 85.71,36.09 85.84,36.09 85.93,36.18 85.93,36.31 85.73,36.51 85.73,36.64 85.83,36.73 85.96,36.73 86.16,36.53 86.29,36.53 86.38,36.63 86.38,36.76 86.18,36.96 86.18,37.09 86.27,37.18 86.41,37.18 86.6,36.98 86.74,36.98 86.83,37.08 86.83,37.21 86.63,37.41 86.63,37.54 86.72,37.63 86.86,37.63 87.05,37.43 87.19,37.43 87.28,37.53 87.28,37.66 87.08,37.86 87.08,37.99 87.17,38.08 87.3,38.08 87.5,37.88 87.63,37.88 87.73,37.97 87.73,38.11 87.53,38.3 87.53,38.44 87.62,38.53 87.75,38.53 87.95,38.33 88.08,38.33 88.18,38.42 88.18,38.55 87.98,38.75 87.98,38.89 88.07,38.98 88.2,38.98 88.4,38.78 88.53,38.78 88.63,38.87 88.63,39 88.43,39.2 88.43,39.33 88.52,39.43 88.65,39.43 88.85,39.23 88.98,39.23 89.07,39.32 89.07,39.45 88.88,39.65 88.88,39.78 88.97,39.88 89.1,39.88 89.3,39.68 89.43,39.68 89.52,39.77 89.52,39.9 89.33,40.1 89.33,40.23 89.42,40.33 89.55,40.33 89.75,40.13 89.88,40.13 89.97,40.22 89.97,40.35 89.77,40.55 89.77,40.68 89.87,40.77 90,40.77 90.2,40.58 90.33,40.58 91.78,42.03 91.78,46.42 93.04,47.68 93.04,47.7 98.21,52.87 99.04,52.87 99.14,52.96 99.14,53.21 99.23,53.31 99.36,53.31 99.46,53.21 99.46,52.96 99.55,52.87 99.87,52.87 101.33,54.33 101.33,54.46 104.38,57.51 104.38,60.95 104.03,61.3 104.03,61.43 104.25,61.66 104.25,61.79 104.16,61.88 104.02,61.88 103.8,61.66 103.67,61.66 102.98,62.35 v1(102.98,63.82)
PTC2/MII_RMII_TXD0/QSPI_A_IO3: length 54.1
  TOP w0.16: U7.43 v1(59.45,59.43) ; U8.51 54.2,61.44 53.99,61.22 v1(53.53,61.22)
  TOP w0.406: R249.1 46.01,37.68 v1(45.91,37.77)
  L3_INT_1 w0.191: v1(51.32,57.95) 50.6,57.23 46.65,57.23 42.31,52.89 41.12,52.89 39.94,51.71 39.94,51.04 39.48,50.58 39.48,48.4 39.65,48.23 39.65,42.46 40.49,41.61 40.49,39.19 42.32,37.37 42.78,37.37 45.29,34.85 46.01,34.85 46.64,35.48 46.64,36.47 45.91,37.2 v1(45.91,37.77)
  L6_INT_2 w0.191: v1(51.32,57.95) 52.74,59.37
  L6_INT_2 w0.203: 52.74,59.37 53.53,60.16 v1(53.53,61.22)
  BOTTOM w0.16: v1(53.53,61.22) 53.99,61.22 54.16,61.4 55.36,61.4 57.33,59.43 v1(59.45,59.43)
PTC2/MII_RMII_TXD0/QSPI_A_IO3_1: length 3.6
  TOP w0.229: 48.09,37.68 v1(48.86,37.68) 48.86,36.99 49.44,36.41 U16.11
  BOTTOM w0.229: v1(48.86,37.68) 48.09,37.68
PTC2/MII_RMII_TXD0/QSPI_A_IO3__: length 4.6
  TOP w0.279: U16.4 54.42,36.41 v1(54.67,36.66) R254.1 R260.1
  BOTTOM w0.279: R260.1 55.17,36.06 55.17,36.16 v1(54.67,36.66)
PTC2/QSPI_A_IO3: length 48.4
  TOP w0.406: v1(57.65,36.26) 57.49,36.41 56.86,36.41 R254.2
  L6_INT_2 w0.191: v1(57.65,36.26) 54.94,36.26 54.87,36.19 53.31,36.19 52.4,35.28 48.59,35.28 48.51,35.36 47.22,35.36 46.72,34.85 41.18,34.85 41.01,34.69 38.16,34.69 v1(37.48,35.37)
  BOTTOM w0.406: R586.1 22.44,36.54 22.17,36.54 21.65,36.01 21.02,36.01 20.87,35.86 20.87,35.63 21.02,35.48 21.65,35.48 21.81,35.32 21.81,33.94 22.67,33.08 30.19,33.08 31.18,32.09 32.72,32.09 33.17,31.63 36.92,31.63 37.48,32.19 v1(37.48,35.37)
PTC3/MII_TX_ER: length 119.7
  TOP w0.406: R212.2 40.4,43.09 40.4,43.09 40.53,42.96 v1(42.08,42.96) ; R55.1 v1(121.25,72.86)
  L6_INT_2 w0.191: v1(42.08,42.96) 42.08,42.49 43.41,41.15 45.15,41.15 45.64,41.63 45.64,41.74 45.92,42.02 45.97,42.02 46.14,42.19 49.12,42.19 50.87,40.44 55.99,40.44 56.57,41.03 84.98,41.03 88.25,44.29 88.25,51.21 93.74,56.7 96.16,56.7 96.63,57.16 96.63,57.17 99.3,59.85 99.3,60.11 99.3,64.78 98.72,65.36 98.72,66.13 95.04,69.8 95.04,71.54 98.23,74.72 99.27,74.72 101.77,77.23 116.87,77.23 v1(121.25,72.86)
PTC3/MII_TX_ER/QSPI_A_CS/QSPI_1: length 3.5
  TOP w0.279: R175.2 38.82,51.78 v1(38.82,51.5) 38.57,51.24 U11.11
  BOTTOM w0.279: v1(38.82,51.5) 38.82,51.78 R175.2
PTC3/MII_TX_ER/QSPI_A_CS/QSPI_2: length 29
  TOP w0.16: U7.42 v1(58.98,59.93) ; U8.50 v1(54.65,61.94)
  TOP w0.406: R175.1 v1(38.19,55.61)
  L3_INT_1 w0.191: 52.74,61.94 44.04,61.94 38.19,56.09 v1(38.19,55.61)
  L3_INT_1 w0.203: 52.74,61.94 v1(54.65,61.94)
  BOTTOM w0.16: v1(58.98,59.93) 57.47,59.93 55.46,61.94 v1(54.65,61.94)
PTC3/MII_TX_ER/QSPI_A_CS/QSPI_B: length 4.9
  TOP w0.279: U11.4 38.57,46.32 v1(38.85,46.04) 38.85,45.65 R212.1 R213.1
  BOTTOM w0.279: v1(38.85,46.04) 39.61,46.04 R213.1
PTC3/QSPI_A_CS: length 48.5
  TOP w0.406: v1(42.48,43.55) 42.22,43.55 41.08,43.55 R213.2
  L6_INT_2 w0.191: v1(42.48,43.55) 41.9,43.55 41.73,43.37 41.59,43.37 41.1,43.86 41.1,43.99 42.28,45.17 42.28,45.3 42.19,45.4 42.06,45.4 40.88,44.22 40.75,44.22 40.66,44.31 40.66,44.44 41.83,45.62 41.83,45.75 41.74,45.85 41.61,45.85 41.01,45.25 40.88,45.25 40.39,45.74 40.26,45.74 40.16,45.65 40.16,45.52 40.66,45.02 40.66,44.89 40.43,44.67 40.3,44.67 39.78,45.19 39.65,45.19 39.55,45.1 39.55,44.97 41.37,43.15 41.37,43.02 41.28,42.92 41.14,42.92 39.33,44.74 39.2,44.74 39.1,44.65 39.1,44.52 40.92,42.7 40.92,42.57 40.83,42.48 40.7,42.48 38.88,44.29 38.75,44.29 38.66,44.2 38.66,44.07 38.88,43.84 38.88,43.71 38.64,43.47 38.64,43.34 38.73,43.24 38.86,43.24 39.11,43.48 39.24,43.48 39.33,43.39 39.33,43.26 39.09,43.02 39.09,42.89 39.18,42.79 39.31,42.79 39.56,43.04 39.69,43.04 39.78,42.94 39.78,42.81 39.54,42.57 39.54,42.44 39.63,42.34 39.76,42.34 40,42.59 40.14,42.59 40.47,42.25 40.47,42.12 40.25,41.9 37.81,41.9 37.5,41.58 37.5,40.9 37.6,40.81 41.27,40.81 41.36,40.71 41.36,40.58 41.27,40.49 39.07,40.49 38.98,40.4 38.98,39.98 38.89,39.89 38.76,39.89 38.66,39.98 38.66,40.4 38.57,40.49 38.44,40.49 38.35,40.4 38.35,39.98 38.25,39.89 38.12,39.89 38.03,39.98 38.03,40.4 37.94,40.49 37.6,40.49 37.5,40.4 37.5,39.45 37.73,39.22 v1(37.73,38.75)
  BOTTOM w0.406: v1(37.73,38.75) 37.73,38.8 37.58,38.8 37.55,38.82 R581.1
PTC4/FTM1_CH0/RTC_CLKOUT/JTAG_T: length 173.9
  TOP w0.16: U8.169 v1(82.91,60.94) ; U7.140 v1(77.63,60.43)
  TOP w0.406: R298.2 35.42,15.62 36.5,16.7 38.06,16.7 38.7,16.06 v1(38.7,15.1)
  L3_INT_1 w0.191: 83.93,60.94 95.08,60.94 96.92,62.78 97.09,62.78 97.36,63.06 97.36,63.52 96.46,64.42 96.46,67.23 97.5,68.26 v1(97.5,69)
  L3_INT_1 w0.203: 83.93,60.94 v1(82.91,60.94)
  L6_INT_2 w0.191: v1(38.7,15.1) 40.32,13.48 97.82,13.48 106.62,22.27 106.62,53.57 108.21,55.16 108.21,69.23 103.74,73.7 100.65,73.7 97.54,70.59 97.54,69.87 97.5,69.82 v1(97.5,69)
  BOTTOM w0.16: v1(82.91,60.94) 79.73,60.94 79.23,60.43 v1(77.63,60.43)
  BOTTOM w0.406: v1(97.5,69) 96.91,68.41 R510.2
PTC5/FTM2_CH0/RTC_CLKOUT/JTAG_T: length 26.9
  TOP w0.16: U7.139 v1(78.1,59.93) ; U8.168 v1(82.44,60.44)
  L3_INT_1 w0.191: 83.93,60.44 95.03,60.44 97.05,62.46 97.22,62.46 97.68,62.93 97.68,63.91 v1(96.94,64.65)
  L3_INT_1 w0.203: 83.93,60.44 v1(82.44,60.44)
  BOTTOM w0.16: v1(78.1,59.93) 81.93,59.93 v1(82.44,60.44)
  BOTTOM w0.406: R516.2 96.13,63.84 v1(96.94,64.65)
PTC6/LPUART1_RX/CAN1_RX/FTM3_CH: length 139
  TOP w0.16: v1(82.87,48.43) U8.144 ; U7.118 v1(77.63,49.43)
  L3_INT_1 w0.191: 80.72,38.62 79.39,37.29 79.39,34.98 78.74,34.32 78.06,34.32 v1(74.66,30.92)
  L3_INT_1 w0.203: v1(77.63,49.43) 78.28,49.43 79.34,48.38 79.34,41.92 80.93,40.33 80.93,38.83 80.72,38.62
  BOTTOM w0.16: v1(82.87,48.43) 81.16,48.43 80.16,49.43 v1(77.63,49.43)
  BOTTOM w0.203: J6.11 83.78,79.22 85,78 85,77.17 87.1,75.07 87.4,75.07 89.09,73.38 89.09,68.33 89.09,68.32 89.09,67.5 89.09,67.5 89.09,67.23 88.84,66.98 88.84,57.94 88.84,57.94 88.84,57.12 88.84,57.11 88.84,56.84 88.53,56.54 88.53,56.49 85.28,53.24 85.28,51.45 84.42,50.58 84.42,49.39 83.45,48.43 v1(82.87,48.43)
  BOTTOM w0.406: R627.2 21.5,11.87 v1(21.65,11.72) 23.18,10.2 28.54,10.2 29.17,10.83 51.23,10.83 56.32,15.92 56.32,20.56 57.54,21.78 71.56,21.78 74.92,25.13 74.92,30.67 v1(74.66,30.92)
PTC7/LPUART1_TX/CAN1_TX/FTM3_CH: length 135.8
  TOP w0.16: v1(82.44,47.9) 82.41,47.93 U8.143 ; U7.117 v1(78.1,48.93)
  L3_INT_1 w0.191: 79.5,38.62 78.75,37.87 78.75,35.25 78.47,34.97 77.38,34.97 72.17,29.76 72.17,25.24 65.35,18.43 56.73,18.43 55.64,17.33 48.57,17.33 41.97,10.73 28.05,10.73 27.84,10.52 25.66,10.52 23.62,12.56 23.62,15.47 v1(22.44,16.65)
  L3_INT_1 w0.203: 79.5,38.62 80.22,39.34 80.22,40.03 78.6,41.65 78.6,45.11 78.26,45.45 77.9,45.45 77.54,45.81 76.72,45.81 76.44,46.09 76.44,47.93 77.45,48.93 v1(78.1,48.93)
  BOTTOM w0.16: v1(78.1,48.93) 80.02,48.93 81.06,47.9 v1(82.44,47.9)
  BOTTOM w0.203: v1(82.44,47.9) 83.42,47.9 84.95,49.42 84.95,50.33 85.81,51.19 85.81,53.31 88.86,56.36 88.86,56.4 89.17,56.7 89.17,56.98 89.17,58.07 89.17,58.07 89.17,66.84 89.42,67.09 89.42,67.37 89.42,68.46 89.42,68.46 89.42,73.52 88.86,74.08 88.86,74.94 87.64,76.15 87.64,78.65 J6.8
  BOTTOM w0.279: v1(22.44,16.65) 22.95,16.14 22.95,16.01
PTC8/LPUART1_RX: length 155.4
  TOP w0.16: U7.81 v1(63.79,44.12) ; 63.29,40.98 v1(63.29,39.32)
  TOP w0.305: v1(19.93,9.73) 19.93,11.2 20.36,11.63 R305.2
  TOP w0.406: R34.1 61.79,75.49 61.73,75.45 61.73,75.47 v1(61.67,75.47)
  L3_INT_1 w0.191: v1(39.69,12.46) 40.5,12.46 48.25,20.2 48.25,23.71 49.66,25.12 49.66,27.08 50.35,27.77 53.46,27.77 54.6,28.91 54.6,29.48 55.39,30.27 59.37,30.27 62.15,33.06 62.15,37.99 62.79,38.62
  L3_INT_1 w0.203: v1(63.29,39.32) 63.29,39.12 62.79,38.62
  L6_INT_2 w0.191: v1(19.93,9.73) 37.72,9.73 39.69,11.69 v1(39.69,12.46)
  L6_INT_2 w0.203: v1(61.67,75.47) 63.48,75.47 67.07,79.06 67.07,80.58 67.88,81.39 75.02,81.39 75.34,81.07 81.7,81.07 82.56,80.21 82.56,74.25 v1(83.63,73.19)
  BOTTOM w0.16: v1(63.79,44.12) 63.79,40.9 63.29,40.4 v1(63.29,39.32)
  BOTTOM w0.203: v1(63.79,44.12) 63.79,44.78 64.24,45.22 65.87,45.22 70.37,49.72 76.7,49.72 77.75,50.77 79.6,50.77 81.72,52.89 82.78,52.89 87.52,57.63 87.52,67.52 87.54,67.55 87.54,72.91 86.92,73.53 83.97,73.53 v1(83.63,73.19)
PTC9/LPUART1_TX: length 144
  TOP w0.16: U7.80 v1(63.29,44.59) ; 62.79,40.98 v1(62.79,39.79)
  TOP w0.406: R14.1 v1(59.91,76.25)
  L3_INT_1 w0.191: v1(57.16,30.74) 59.17,30.74 61.84,33.41 61.84,38.17 62.28,38.62
  L3_INT_1 w0.203: 62.28,38.62 62.79,39.12 v1(62.79,39.79)
  L6_INT_2 w0.191: v1(79.32,64.67) 79.32,62.48 78.3,61.45 77.79,61.45 77.33,61.91 76.72,61.91 76.37,61.55 75.85,61.55 73.4,59.11 73.4,55.79 74.02,55.17 77.15,55.17 78.52,53.8 78.52,51.68 76.07,49.24 67.93,49.24 v1(63.29,44.59) ; v1(47.6,14.63) 44.81,17.42 33.5,17.42 33.45,17.46 26.99,17.46 26.09,16.56 v1(24.57,16.56) ; v1(59.91,76.25) 61.47,74.69 63.49,74.69 67.65,78.85 73.76,78.85 74.97,77.64 74.97,77.07 75.73,76.31 76.08,76.31 77.41,74.99 v1(77.41,74.51)
  BOTTOM w0.16: v1(62.79,39.79) 62.98,39.97 62.98,40.53 63.29,40.85 v1(63.29,44.59)
  BOTTOM w0.203: v1(79.32,64.67) 82.08,67.42 82.08,69.05
  BOTTOM w0.406: v1(57.16,30.74) 57.16,23.18 55.46,21.47 50.94,21.47 49.8,20.33 49.8,16.83 v1(47.6,14.63) ; v1(77.41,74.51) 82.08,69.84 82.08,69.05 ; R619.2 24.43,16.56 v1(24.57,16.56)
PTC10/FTM3_CH4/TRGMUX_IN11: length 55.5
  TOP w0.16: 60.29,40.98 v1(60.29,39.32) ; U7.75 v1(60.79,44.12)
  L6_INT_2 w0.203: v1(60.79,44.12) 60.31,43.64 55.98,43.64 55.21,44.41 53.73,44.41 53.27,43.94 52.57,43.94 47.89,48.62 47.89,55.59 52.74,60.44 v1(52.74,60.92)
  BOTTOM w0.16: v1(60.79,44.12) 60.79,41.1 60.29,40.6 v1(60.29,39.32)
  BOTTOM w0.203: 53.84,69.05 52.74,67.96 v1(52.74,60.92)
  BOTTOM w0.406: 53.84,69.05 53.84,73.75 55.84,75.75 J1.10
PTC11/FTM3_CH5/FTM4_CH2/TRGMUX_: length 57.1
  TOP w0.16: U7.74 v1(60.29,44.59) ; 59.28,40.98 v1(59.28,39.32)
  TOP w0.406: J1.7 57.04,76.08 49.26,76.08 48.3,75.12 v1(48.3,74.53)
  L3_INT_1 w0.191: v1(48.3,74.53) 48.64,74.2 49.04,74.2 54.19,69.05
  L3_INT_1 w0.203: v1(60.29,44.59) 60.28,44.61 59.59,44.61 59.43,44.45 58.78,44.45 58.5,44.73 58.5,65.24 55.92,67.83 55.41,67.83 54.19,69.05
  BOTTOM w0.16: v1(60.29,44.59) 60.29,41.75 59.28,40.74 v1(59.28,39.32)
PTC12: length 10.7
  TOP w0.16: U7.71 v1(59.52,45.43) ; U8.84 v1(54.65,44.92)
  BOTTOM w0.16: v1(59.52,45.43) 55.15,45.43 v1(54.65,44.92)
  BOTTOM w0.203: v1(59.52,45.43) 59.73,45.43 60.36,46.06 R567.2 R565.2
PTC12/BTN0: length 95.8
  TOP w0.406: R306.2 C109.1 v1(93.66,14.13)
  L3_INT_1 w0.191: v1(47.13,23.38) 47.13,25.41 48.71,26.99 48.71,32.53 50.32,34.14 50.32,43.66 v1(51.96,45.3)
  L6_INT_2 w0.191: v1(63.94,46.8) 62.83,47.91 59.63,47.91 59.18,47.45 54.11,47.45 v1(51.96,45.3) ; v1(93.66,14.13) 93.19,14.13 92.86,13.8 51.4,13.8 v1(47.13,18.07)
  BOTTOM w0.203: v1(63.94,46.8) 63.89,46.75 TP507.1 62.88,47.03 R565.1
  BOTTOM w0.406: v1(47.13,23.38) v1(47.13,18.07)
PTC12/FTM3_CH6/FTM2_CH6/LPUART2: length 53.2
  L3_INT_1 w0.191: J6.5 87.75,78.86 87.75,73.91 v1(86.8,72.96)
  BOTTOM w0.203: R567.1 65.29,46.06 70.14,50.91 77.39,50.91 77.6,51.12 78.94,51.12 81.9,54.09 83.47,54.09 87.19,57.8 87.19,67.66 87.21,67.69 87.21,72.55 v1(86.8,72.96)
PTC13: length 12.1
  TOP w0.16: U7.70 v1(58.98,45.93) ; U8.81 v1(54.18,46.43)
  BOTTOM w0.16: v1(58.98,45.93) 55.59,45.93 55.1,46.43 v1(54.18,46.43)
  BOTTOM w0.203: R561.2 R562.2 60.44,47.38 60.44,46.73 59.64,45.93 v1(58.98,45.93)
PTC13/BTN1: length 78.9
  TOP w0.406: v1(97.62,13.96) C110.1 R307.2
  L3_INT_1 w0.191: v1(84.67,30.72) 87.7,33.75 87.7,43.95 87.69,43.96 87.69,53.11 85.57,55.24 85.25,55.24 v1(84.59,55.89)
  BOTTOM w0.203: R562.1 63.13,47.99 TP506.1 66.59,51.39 76.88,51.39 77.84,52.36 79.34,52.36 82.21,55.24 83.93,55.24
  BOTTOM w0.406: v1(97.62,13.96) 96.18,13.96 85.1,25.03 85.1,30.29 v1(84.67,30.72) ; v1(84.59,55.89) 83.93,55.24
PTC13/FTM3_CH7/FTM2_CH7/LPUART2: length 52
  L3_INT_1 w0.191: J6.2 92.51,78.86 92.51,75.67 v1(86.73,69.89)
  BOTTOM w0.191: R561.1 63.56,48.96 66.38,51.78 76.76,51.78 77.7,52.71 78.2,52.71 81.33,55.84 82.54,55.84 83.11,56.41
  BOTTOM w0.203: 83.11,56.41 83.93,57.24
  BOTTOM w0.406: 83.93,57.24 86.73,60.03 v1(86.73,69.89)
PTC14/FTM1_CH2/LPSPI2_PCS0/ADC0: length 55.4
  TOP w0.16: U7.61 v1(60.69,50.43) ; U8.70 v1(54.65,51.93)
  TOP w0.406: J5.13 88.86,30.41 87.31,31.96 83.19,31.96 79.71,35.44 v1(78.27,35.44)
  L3_INT_1 w0.191: 79,38.62 78.27,37.89 v1(78.27,35.44)
  L3_INT_1 w0.203: 79,38.62 79.86,39.48 79.86,39.88 78.19,41.55 78.19,44.12 77.6,44.71 77.05,44.71 76.01,45.76 64.3,45.76 60.69,49.37 v1(60.69,50.43)
  BOTTOM w0.16: v1(60.69,50.43) 57.06,50.43 55.56,51.93 v1(54.65,51.93)
PTC15/FTM1_CH3/LPSPI2_SCK/QSPI_: length 75.7
  TOP w0.16: U8.67 v1(54.18,53.43) ; U7.59 v1(59.45,51.43)
  L3_INT_1 w0.191: 52.74,53.43 50.71,53.43 47.89,50.61 47.89,45.25 46.7,44.05 46.7,40.85 46.6,40.75 46.6,39.42 47.05,38.97 47.05,37.4 47.66,36.8 47.66,35.75 48.4,35.01 48.4,34.51 46.89,33.01 v1(46.89,28.74)
  L3_INT_1 w0.203: v1(54.18,53.43) 52.74,53.43
  L6_INT_2 w0.191: J5.2 69.98,22.99 60.47,22.99 59.81,23.65 59.81,24.21 58.52,25.51 55.26,25.51 54.41,24.66 54.41,23.65 53.76,22.99 50.31,22.99 46.8,26.5 46.8,28.17 46.89,28.26 v1(46.89,28.74)
  BOTTOM w0.16: v1(54.18,53.43) 55.46,53.43 57.46,51.43 v1(59.45,51.43)
PTC16/MII_RMII_RX_ER: length 157.6
  TOP w0.406: v1(41.47,48.8) 42.18,49.52 R195.2 ; R61.1 v1(121.22,71.84)
  L6_INT_2 w0.191: v1(121.22,71.84) 116.15,76.92 101.96,76.92 99.45,74.41 98.36,74.41 95.36,71.41 95.36,69.94 98.44,66.86 101.65,66.86 102.17,66.35 102.17,65.76 101.87,65.47 101.87,61.14 103.11,59.9 103.11,58.04 100.06,54.98 100.06,54.85 99.78,54.58 98.12,54.58 91.77,48.22 91.77,48.21 90.48,46.91 90.48,43.37 85.47,38.36 83.65,38.36 82.6,37.31 76.33,37.31 74.32,35.3 66.19,35.3 65.3,34.41 61.7,34.41 60.73,35.38 55.83,35.38 54.58,34.13 49.43,34.13 48.88,33.58 47.05,33.58 46.53,34.1 41.33,34.1 41.15,33.93 36.4,33.93 35.09,35.24 32.18,35.24 30.09,37.33 30.09,40.97 34.01,44.89 38.38,44.89 41.47,47.98 v1(41.47,48.8)
PTC16/MII_RMII_RX_ER/QSPI_B_I_1: length 31.8
  TOP w0.16: U7.57 v1(59.45,52.43) ; U8.65 v1(54.18,54.43)
  TOP w0.406: R230.1 v1(43.6,39.11)
  L3_INT_1 w0.191: 52.74,54.43 50.81,54.43 47.24,50.86 47.24,45.58 44.48,42.83 44.48,40 v1(43.6,39.11)
  L3_INT_1 w0.203: 52.74,54.43 v1(54.18,54.43)
  BOTTOM w0.16: v1(54.18,54.43) 55.41,54.43 57.41,52.43 v1(59.45,52.43)
