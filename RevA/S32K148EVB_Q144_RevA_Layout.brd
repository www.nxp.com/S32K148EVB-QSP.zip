# Allegro board S32K148EVB_Q144_RevA_Layout.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PTC16/MII_RMII_RX_ER/QSPI_B_I_2: length 3.3
  TOP w0.279: v1(44,41.62) 44.37,41.99 44.37,42.03 44.55,42.21 U13.10
  TOP w0.406: R230.2 43.6,41.26 43.95,41.62 43.95,41.62 v1(44,41.62)
  BOTTOM w0.279: v1(44,41.62) 43.95,41.62 43.95,41.62 43.6,41.26 R230.2
PTC16/MII_RMII_RX_ER/QSPI_B_IO7: length 4.9
  TOP w0.279: R195.1 42.35,47.71 v1(42.41,47.66) 42.41,47.41 42.77,47.04 44.31,47.04 44.55,46.8 U13.5
  BOTTOM w0.279: v1(42.41,47.66) 42.35,47.71 R195.1
PTC17/MII_RMII_RX_DV: length 103.5
  TOP w0.406: R196.2 43.37,50.16 43.32,50.21 v1(43.32,51.7) ; R81.2 v1(102.68,67.52)
  L6_INT_2 w0.191: v1(94.81,72.63) 94.81,71.98 94.72,71.9 94.72,67.24 95.1,66.87 95.1,64.34 98.98,60.45 98.98,59.98 96.31,57.31 96.31,57.29 96.03,57.01 93.6,57.01 87.93,51.35 87.93,45.32 86.43,43.82 86.43,43.5 84.3,41.37 56.43,41.37 55.84,40.78 50.98,40.78 44.21,47.55 44.21,49.31 43.32,50.2 v1(43.32,51.7)
  BOTTOM w0.406: v1(102.68,67.52) 102.27,67.94 102.27,70.3 101.82,70.75 98.82,70.75 96.94,72.63 v1(94.81,72.63)
PTC17/MII_RMII_RX_DV/QSPI_B_I_1: length 3.2
  TOP w0.279: U13.11 v1(45.05,41.72) 44.95,41.72 44.62,41.39 R231.2
  BOTTOM w0.279: R231.2 44.62,41.39 44.95,41.72 v1(45.05,41.72)
PTC17/MII_RMII_RX_DV/QSPI_B_I_2: length 33.1
  TOP w0.16: U8.64 v1(54.65,54.93) ; U7.56 v1(58.98,52.93)
  TOP w0.406: R231.1 v1(44.62,39.11)
  L3_INT_1 w0.191: 52.74,54.93 50.86,54.93 46.92,50.99 46.92,45.72 43.8,42.61 43.8,42.15 43.12,41.47 43.12,38.92 43.4,38.64 44.14,38.64 v1(44.62,39.11)
  L3_INT_1 w0.203: 52.74,54.93 v1(54.65,54.93)
  BOTTOM w0.16: v1(54.65,54.93) 55.39,54.93 57.39,52.93 v1(58.98,52.93)
PTC17/MII_RMII_RX_DV/QSPI_B_IO6: length 4.2
  TOP w0.279: U13.4 45.05,46.95 44.25,47.75 v1(43.37,47.75) R196.1
  BOTTOM w0.279: v1(43.37,47.75) R196.1
PTC18/FTM7_CH4: length 47.2
  TOP w0.16: U8.83 v1(54.18,45.42)
  BOTTOM w0.191: J2.3 42.68,82.51 43.49,81.7 43.49,76.03 41.5,74.03 41.5,59.53 48.7,52.32 48.7,52.25 48.74,52.21 48.74,51.77
  BOTTOM w0.203: v1(54.18,45.42) 53.84,45.08 53.29,45.08 49.8,48.58 49.8,49.31 48.76,50.35 48.76,51.76 48.74,51.77
PTC19/FTM7_CH5/ADC0_SE25: length 71
  TOP w0.16: U7.72 v1(58.98,44.93) ; U8.85 v1(52.77,44.42)
  L3_INT_1 w0.191: v1(48.87,26.43) 49.03,26.59 49.03,32.21 50.63,33.82 50.63,42.29 52.74,44.4
  L3_INT_1 w0.203: v1(52.77,44.42) 52.74,44.4
  L6_INT_2 w0.191: v1(48.87,26.43) 50.17,27.73 61.38,27.73 62.35,26.75 62.35,26.19 63.01,25.53 69.02,25.53 71.33,27.85 85,27.85 J5.11
  BOTTOM w0.16: v1(58.98,44.93) 58.48,44.42 v1(52.77,44.42)
PTC20/FTM7_CH6: length 48.4
  TOP w0.16: U8.86 v1(54.65,43.92)
  BOTTOM w0.191: J2.6 37.95,81.39 37.95,78.4 37.93,78.38 37.93,62.57 48.43,52.08 48.43,51.92 48.42,51.91 48.42,51.64 48.43,51.63 48.43,50.2
  BOTTOM w0.203: 48.43,50.2 49.47,49.16 49.47,47.04 52.59,43.92 v1(54.65,43.92)
PTC21/FTM7_CH7/FTM7_FLT0: length 50.8
  TOP w0.16: U8.87 v1(54.18,43.42)
  BOTTOM w0.191: J2.9 35.41,81.39 35.41,76.84 34.32,75.74 34.32,65.75 37.65,62.41 37.65,62.41 48.08,51.97 48.08,50.72
  BOTTOM w0.203: 48.08,50.72 48.09,50.72 48.09,49.51 48.47,49.13 48.47,47.57 52.57,43.47 53.08,43.47 53.12,43.51 53.81,43.51 53.85,43.47 54.13,43.47 v1(54.18,43.42)
PTC22/FTM7_FLT1: length 51.4
  TOP w0.16: U8.88 v1(54.65,42.92)
  BOTTOM w0.191: 52.94,43.11 52.47,43.11 48.15,47.44 48.15,48.99 47.76,49.37 47.76,50.58 47.76,50.59 47.76,50.86 47.76,50.87 47.76,51.84 34,65.61 34,75.88 35.1,76.97 35.1,81.41 J2.12
  BOTTOM w0.203: 52.94,43.11 53.23,43.11 53.27,43.15 53.67,43.15 53.9,42.92 v1(54.65,42.92)
PTC23/LPSPI0_SCK/ADC0_SE26: length 28.3
  TOP w0.16: v1(57.85,39.78) 57.78,39.78 57.78,40.98 ; U7.73 v1(59.79,44.12)
  L3_INT_1 w0.191: J4.1 52.39,30.8 54.97,30.8 55.71,31.54 58.88,31.54 61.2,33.85 61.2,36.72 59.12,38.8 57.82,38.8 57.51,39.11 57.51,39.44 v1(57.85,39.78)
  BOTTOM w0.16: v1(57.85,39.78) 59.79,41.72 v1(59.79,44.12)
PTC24/FTM4_CH0: length 58.6
  TOP w0.16: 58.28,40.98 58.28,39.99 58.31,39.97 58.31,39.75 58.32,39.73 v1(58.32,39.27)
  BOTTOM w0.191: 52.72,42.61 52.53,42.61 47.83,47.31 47.83,48.86 47.43,49.25 47.43,51.39 47.43,51.4 47.43,51.73 41.04,58.12 40.77,58.12 40.76,58.11 40.72,58.11 33.64,65.19 33.64,72.96 30.36,76.24 30.36,81.41 J2.15
  BOTTOM w0.203: 52.72,42.61 53.26,42.06 54.66,42.06 54.96,41.77 55.17,41.77 55.22,41.72 57.67,39.27 v1(58.32,39.27)
PTC25/FTM4_CH1: length 61.5
  TOP w0.16: 58.78,40.98 v1(58.78,39.79)
  BOTTOM w0.191: J2.18 27.82,81.41 27.82,69.57 39.6,57.8 40.9,57.8
  BOTTOM w0.203: 40.9,57.8 47.1,51.59 47.1,49.13 47.5,48.73 47.5,47.17 52.45,42.23 52.54,42.23 53.06,41.71 54.52,41.71 54.86,41.36 55.08,41.36 57.65,38.79 58.52,38.79 58.8,39.07 58.8,39.77 v1(58.78,39.79)
PTC26/FTM4_CH3: length 63.4
  TOP w0.16: 59.79,40.98 v1(59.79,39.79)
  BOTTOM w0.191: 59.47,38.82 59.09,38.44 57.29,38.44 54.37,41.36 52.86,41.36 47.18,47.04 47.18,48.59 46.76,49.01 46.76,50.31 39.6,57.48 39.46,57.48 25.28,71.66 25.28,81.41 J2.21
  BOTTOM w0.203: 59.47,38.82 59.79,39.14 v1(59.79,39.79)
PTC27/FTM4_CH4/FTM4_CH4/ADC0_SE: length 24.3
  TOP w0.16: U7.76 v1(61.29,44.59) ; 60.79,40.98 v1(60.79,39.79)
  L3_INT_1 w0.191: 61.24,38.62 61.52,38.34 61.52,33.72 59.02,31.22 55.84,31.22 55.1,30.48 54.61,30.48 J4.4
  L3_INT_1 w0.203: v1(60.79,39.79) 60.79,39.07 61.24,38.62
  BOTTOM w0.16: v1(60.79,39.79) 60.79,40.31 61.29,40.81 v1(61.29,44.59)
PTC28: length 9.6
  TOP w0.203: U7.79 v1(62.79,44.12) ; 62.29,40.98 v1(62.29,39.3)
  TOP w0.279: v1(62.29,39.3) 62.29,39.3 R246.2
  BOTTOM w0.203: 62.29,38.62 v1(62.29,39.3) 62.29,40.19 62.64,40.54 62.64,40.67 62.79,40.82 v1(62.79,44.12)
  BOTTOM w0.406: 62.29,38.62 62.29,38.35 R583.2
PTC28/FTM4_CH7/FTM4_CH7/ADC0_SE: length 17.7
  TOP w0.406: R246.1 63.31,37.79 v1(63.51,37.59)
  L3_INT_1 w0.191: v1(63.51,37.59) 63.85,37.25 63.85,31.44 62.34,29.93 62.34,29.04 61.38,28.07 56.94,28.07 J4.7
PTC29/FTM5_CH2/FTM5_CH2/ADC0_SE: length 21.3
  TOP w0.16: 63.79,40.98 v1(63.79,39.79) ; U7.82 v1(64.29,44.59)
  L3_INT_1 w0.191: 63.3,38.62 62.47,37.79 62.47,32.33 59.9,29.76 59.9,29.64 59.43,29.17 J4.10
  L3_INT_1 w0.203: 63.3,38.62 63.79,39.11 v1(63.79,39.79)
  BOTTOM w0.16: v1(64.29,44.59) 64.29,40.89 63.79,40.39 v1(63.79,39.79)
PTC30/FTM5_CH4/FXIO_D0/LPI2C1_S: length 40.3
  TOP w0.16: 64.79,40.98 v1(64.79,39.79) ; U7.84 v1(65.29,44.59)
  TOP w0.406: R320.1 v1(58.13,12.37) ; J4.13 62.19,27.9 62.19,21.75 v1(58.15,17.71)
  L3_INT_1 w0.191: 63.87,38.62 62.8,37.55 62.8,32.1 60.92,30.22 J4.13
  L3_INT_1 w0.203: 63.87,38.62 64.27,38.62 64.79,39.14 v1(64.79,39.79)
  BOTTOM w0.16: v1(65.29,44.59) 65.29,40.75 64.79,40.25 v1(64.79,39.79)
  BOTTOM w0.406: v1(58.13,12.37) 58.13,12.96 58.15,12.98 v1(58.15,17.71)
PTC31/FTM5_CH6/FXIO_D1/LPI2C1_S: length 55
  TOP w0.16: 65.79,40.98 v1(65.79,39.79) ; U7.86 v1(66.29,44.59)
  TOP w0.406: R313.1 42.08,13.12 47.79,13.12 51.79,17.12 58.38,17.12 64.76,23.49 64.76,27.87 J4.16
  L3_INT_1 w0.191: 65.79,38.62 65.79,31.5 J4.16
  L3_INT_1 w0.203: 65.79,38.62 v1(65.79,39.79)
  BOTTOM w0.16: v1(65.79,39.79) 65.79,40.1 66.29,40.61 v1(66.29,44.59)
PTD0/FTM0_CH2/FTM2_CH0/TRACE_D0: length 60.3
  TOP w0.16: U8.8 v1(75.8,67.57) ; U7.4 v1(75.79,63.24)
  TOP w0.406: R122.2 95.72,60.03 v1(95.92,59.83)
  L3_INT_1 w0.191: J6.29 69.66,78.85 69.66,75.19 75.8,69.05
  L3_INT_1 w0.203: 75.8,69.05 v1(75.8,67.57)
  L6_INT_2 w0.191: v1(95.92,59.83) 95.45,59.83 80,75.28 79.3,75.28 77.26,77.32 77.26,77.88 76.3,78.85 75.73,78.85 74.72,79.86 74.72,80.42 74.08,81.07 69.64,81.07 J6.29
  BOTTOM w0.16: v1(75.79,63.24) 75.79,67.11 75.8,67.11 v1(75.8,67.57)
PTD1/FTM0_CH3/LPSPI1_SIN/FTM2_C: length 109.7
  TOP w0.16: U7.3 v1(76.29,62.77) ; U8.7 v1(76.3,68.04)
  TOP w0.406: R323.1 v1(65.75,12.33)
  L3_INT_1 w0.191: v1(92.44,68.74) 88.96,65.26 84.47,65.26 v1(84.09,65.64) ; v1(65.75,12.33) 66.54,11.54 81.32,11.54 93.94,24.16 J5.18
  L6_INT_2 w0.191: v1(76.3,68.04) 76.77,68.52 81.33,68.52 81.77,68.08 81.77,67.96 v1(84.09,65.64)
  BOTTOM w0.16: v1(76.29,62.77) 76.29,67.58 76.3,67.58 v1(76.3,68.04)
  BOTTOM w0.406: v1(92.44,68.74) 92.44,51.04 96.44,47.04 96.44,33.65 95.24,32.45 95.24,27.93 J5.18
PTD2/FTM3_CH4/LPSPI1_SOUT/FXIO_: length 63
  TOP w0.16: U7.102 v1(74.29,44.59) ; 74.8,40.98 v1(74.8,39.32)
  L6_INT_2 w0.191: 83.93,48.2 85.16,49.42 85.16,50.83 87.23,52.9 87.23,66.42 81.33,72.32 75.14,72.32 71.08,76.38 J6.25
  L6_INT_2 w0.203: v1(74.29,44.59) 74.29,43.94 74.95,43.29 79.14,43.29 82.24,46.38 82.65,46.38 82.67,46.37 83.35,46.37 83.65,46.67 83.65,47.92 83.93,48.2
  BOTTOM w0.16: v1(74.8,39.32) 74.8,41.84 74.29,42.34 v1(74.29,44.59)
PTD3/FTM3_CH5/LPSPI1_PCS0/FXIO_: length 69.8
  TOP w0.16: 74.3,40.98 v1(74.3,39.79) ; U7.101 v1(73.79,44.12)
  L6_INT_2 w0.191: v1(73.79,44.12) 73.79,43.65 74.5,42.94 82.12,42.94 84.79,45.6 84.79,47.41 85.38,48 86.23,48 86.94,48.71 86.94,51.7 89.92,54.68 89.92,64.18 81.46,72.64 75.58,72.64 72.18,76.04 72.18,77.88 71.54,78.53 69.64,78.53 J6.28
  BOTTOM w0.16: v1(73.79,44.12) 73.79,41.95 74.3,41.45 v1(74.3,39.79)
PTD4/FTM0_FLT3/ADC1_SE6: length 45.7
  TOP w0.16: 73.8,40.98 v1(73.8,39.32) ; U7.100 v1(73.29,44.59)
  L3_INT_1 w0.191: 73.8,38.62 70.9,35.73 70.9,27.44 69,25.53 57.93,25.53 56.95,26.5 56.95,27.07 56.3,27.73 55.39,27.73 54.73,27.07 54.73,26.5 53.76,25.53 51.86,25.53 J4.2
  L3_INT_1 w0.203: 73.8,38.62 v1(73.8,39.32)
  BOTTOM w0.16: v1(73.29,44.59) 73.29,41.44 73.8,40.93 v1(73.8,39.32)
PTD5/MII_TXD3: length 104
  TOP w0.406: v1(102.86,60.82) 103.22,60.82 103.57,61.17 R115.2 ; R270.2 v1(41.21,32.55)
  L6_INT_2 w0.191: v1(102.86,60.82) 103.43,60.25 103.43,57.9 100.37,54.85 100.37,54.72 99.91,54.26 98.26,54.26 92.09,48.09 92.09,48.07 90.79,46.78 90.79,43.24 85.56,38.01 83.75,38.01 83.17,37.43 82.73,36.99 81.73,36.99 81.64,36.9 81.64,36.41 81.55,36.32 81.41,36.32 81.32,36.41 81.32,36.9 81.23,36.99 80.91,36.99 80.82,36.9 80.82,35.84 80.72,35.75 80.59,35.75 80.5,35.84 80.5,36.9 80.41,36.99 80.28,36.99 80.18,36.9 80.18,35.84 80.09,35.75 79.96,35.75 79.86,35.84 79.86,36.9 79.77,36.99 79.64,36.99 79.55,36.9 79.55,35.84 79.45,35.75 79.32,35.75 79.23,35.84 79.23,36.9 79.14,36.99 78.82,36.99 78.73,36.9 78.73,36.01 78.63,35.92 78.5,35.92 78.41,36.01 78.41,36.9 78.32,36.99 78.18,36.99 78.09,36.9 78.09,36.01 78,35.92 77.87,35.92 77.77,36.01 77.77,36.9 77.68,36.99 77.55,36.99 77.46,36.9 77.46,36.01 77.36,35.92 77.23,35.92 77.14,36.01 77.14,36.9 77.05,36.99 76.47,36.99 76.14,36.66 76.14,36.53 76.44,36.22 76.44,36.09 76.35,36 76.22,36 75.91,36.31 75.78,36.31 75.69,36.21 75.69,36.08 76,35.77 76,35.64 75.9,35.55 75.77,35.55 75.46,35.86 75.33,35.86 75.24,35.76 75.24,35.63 75.55,35.32 75.55,35.19 75.45,35.1 75.32,35.1 75.01,35.41 74.88,35.41 74.44,34.97 66.33,34.97 65.45,34.09 64.46,34.09 64.37,34 64.37,33.47 64.27,33.38 64.14,33.38 64.05,33.47 64.05,34 63.96,34.09 61.57,34.09 60.6,35.06 57.2,35.06 57.1,34.97 57.1,34.76 57.01,34.67 56.88,34.67 56.79,34.76 56.79,34.97 56.69,35.06 56.1,35.06 54.85,33.82 49.56,33.82 49.01,33.27 46.87,33.27 46.35,33.79 43.98,33.79 43.89,33.69 43.89,33.13 43.8,33.04 43.67,33.04 43.57,33.13 43.57,33.69 43.48,33.79 43.35,33.79 43.26,33.69 43.26,33.13 43.16,33.04 43.03,33.04 42.94,33.13 42.94,33.69 42.84,33.79 42.44,33.79 41.95,33.29 41.82,33.29 41.46,33.65 41.33,33.65 41.24,33.56 41.24,33.43 41.6,33.07 41.6,32.94 v1(41.21,32.55)
PTD5/MII_TXD3/QSPI_B_IO2: length 49.6
  TOP w0.16: U8.54 v1(54.65,59.94) ; U7.46 v1(58.98,57.93)
  L3_INT_1 w0.191: v1(40.42,54.72) 41.82,54.72 46.55,59.45 51.55,59.45 51.75,59.65 53.15,59.65 53.44,59.94 v1(54.65,59.94)
  L6_INT_2 w0.191: v1(40.42,54.72) 41.32,53.83 41.32,50.19 41.09,49.97 41.09,49.57 41.37,49.29 41.65,49.29 41.94,49 41.94,47.93 37.29,43.29 37.29,43.27 37.19,43.16 37.19,38.62 37.53,38.27 37.97,38.27 39.7,40 v1(41.63,40)
  BOTTOM w0.16: v1(58.98,57.93) 57.12,57.93 55.11,59.94 v1(54.65,59.94)
  BOTTOM w0.406: R580.1 41.36,39.74 v1(41.63,40)
PTD5/MII_TXD3/QSPI_B_IO2__A: length 2.9
  TOP w0.279: v1(40.02,41.41) 40.02,41.36 39.84,41.18 U14.11
  BOTTOM w0.279: v1(40.02,41.41) 40.02,41.79 R570.2
  BOTTOM w0.406: R580.2 40.4,41.03 v1(40.02,41.41)
PTD5/MII_TXD3/QSPI_B_IO2__B: length 4.6
  TOP w0.279: U14.4 39.84,36.07 40.14,35.76 v1(40.14,35.24) 40.65,34.74 40.8,34.74 R270.1
  BOTTOM w0.279: R270.1 40.8,34.74 40.65,34.74 v1(40.14,35.24)
PTD6/MII_TXD2: length 104.3
  TOP w0.406: R111.2 103.82,62.19 103.48,62.53 103.48,62.53 v1(103.48,62.53) ; R269.2 v1(40.2,32.56)
  L3_INT_1 w0.191: v1(107.1,58.91) 103.82,62.19 103.82,62.19 v1(103.48,62.53)
  L6_INT_2 w0.191: v1(40.2,32.56) 40.76,32 50.83,32 51.23,32.39 55.87,32.39 56.57,33.09 57.25,33.09 57.51,32.83 58.42,32.83 58.44,32.85 59.1,32.85 59.76,32.19 60.73,32.19 60.8,32.11 79.4,32.11 79.65,31.86 84.98,31.86 93.67,40.55 93.67,40.68 93.11,41.24 93.11,41.37 93.21,41.46 93.34,41.46 93.9,40.9 94.03,40.9 94.12,41 94.12,41.13 93.56,41.69 93.56,41.82 93.66,41.91 93.79,41.91 94.35,41.35 94.48,41.35 94.57,41.44 94.57,41.58 94.01,42.14 94.01,42.27 94.1,42.36 94.24,42.36 94.8,41.8 94.93,41.8 97.06,43.93 97.06,44.07 96.34,44.79 96.34,44.92 96.44,45.01 96.57,45.01 97.29,44.29 97.42,44.29 97.51,44.38 97.51,44.51 96.79,45.23 96.79,45.37 96.88,45.46 97.02,45.46 97.74,44.74 97.87,44.74 97.96,44.83 97.96,44.96 97.24,45.68 97.24,45.81 97.33,45.91 97.47,45.91 98.18,45.19 98.32,45.19 98.41,45.28 98.41,45.41 97.69,46.13 97.69,46.26 97.78,46.36 97.91,46.36 98.63,45.64 98.77,45.64 98.99,45.86 98.99,50.73 100.15,51.89 102.23,51.89 107.1,56.76 v1(107.1,58.91)
PTD6/MII_TXD2/QSPI_B_IO1: length 47.3
  TOP w0.16: U8.53 v1(54.18,60.44) ; U7.45 v1(59.45,58.43)
  TOP w0.279: v1(36.31,42.96) 36.59,42.96 36.6,42.95 38.49,42.95 38.68,43.14 R223.1
  L3_INT_1 w0.191: 52.74,60.08 51.9,60.08 51.5,60.48 46.06,60.48 41.22,55.64 39.03,55.64 38.52,55.13 37.99,55.13 37.84,55.29 36.23,55.29 35.77,54.82 35.77,53.7 36.1,53.36 36.1,51.96 34.26,50.12 34.26,45.01 v1(36.31,42.96)
  L3_INT_1 w0.203: v1(54.18,60.44) 54.1,60.36 53.37,60.36 53.09,60.08 52.74,60.08
  BOTTOM w0.16: v1(59.45,58.43) 57.1,58.43 55.19,60.34 55.06,60.44 v1(54.18,60.44)
PTD6/MII_TXD2/QSPI_B_IO1__A: length 3.1
  TOP w0.279: R223.2 38.96,41.75 38.96,41.39 v1(38.94,41.38) 39.34,40.98 U14.12
  BOTTOM w0.279: v1(38.94,41.38) 38.96,41.39 38.96,41.75 R223.2
PTD6/MII_TXD2/QSPI_B_IO1__B: length 4.1
  TOP w0.279: R269.1 39.73,34.8 39.71,34.8 v1(39.34,35.16) U14.3
  BOTTOM w0.279: v1(39.34,35.16) 39.71,34.8 39.73,34.8 R269.1
PTD7/MII_RMII_TXD1: length 103.5
  TOP w0.406: R272.2 v1(44.46,33.31) ; R109.2 v1(103.57,63.21)
  L6_INT_2 w0.191: v1(103.57,63.21) 104.12,62.66 104.25,62.66 104.34,62.75 104.47,62.75 104.57,62.66 104.57,62.52 104.47,62.43 104.47,62.3 104.7,62.08 104.7,57.38 101.64,54.32 101.64,54.2 100,52.55 98.34,52.55 93.36,47.56 93.36,47.55 92.1,46.29 92.1,41.9 91.38,41.18 91.38,41.05 91.74,40.69 91.74,40.56 91.65,40.47 91.52,40.47 91.16,40.83 91.03,40.83 90.94,40.73 90.94,40.6 91.29,40.24 91.29,40.11 91.2,40.02 91.07,40.02 90.71,40.38 90.58,40.38 90.49,40.28 90.49,40.15 90.84,39.8 90.84,39.66 90.75,39.57 90.62,39.57 90.26,39.93 90.13,39.93 90.04,39.83 90.04,39.7 90.39,39.35 90.39,39.22 90.3,39.12 90.17,39.12 89.81,39.48 89.68,39.48 89.59,39.39 89.59,39.25 89.94,38.9 89.94,38.77 89.85,38.67 89.72,38.67 89.36,39.03 89.23,39.03 89.14,38.94 89.14,38.8 89.5,38.45 89.5,38.32 89.4,38.22 89.27,38.22 88.91,38.58 88.78,38.58 88.69,38.49 88.69,38.36 89.05,38 89.05,37.87 88.95,37.77 88.82,37.77 88.47,38.13 88.33,38.13 88.24,38.04 88.24,37.91 88.6,37.55 88.6,37.42 88.5,37.33 88.37,37.33 88.02,37.68 87.88,37.68 87.79,37.59 87.79,37.46 88.15,37.1 88.15,36.97 88.05,36.88 87.92,36.88 87.57,37.23 87.44,37.23 87.34,37.14 87.34,37.01 87.7,36.65 87.7,36.52 87.61,36.43 87.47,36.43 87.12,36.78 86.99,36.78 86.89,36.69 86.89,36.56 87.25,36.2 87.25,36.07 87.16,35.98 87.03,35.98 86.67,36.33 86.54,36.33 85.22,35.02 85.22,34.89 85.58,34.53 85.58,34.4 85.48,34.3 85.35,34.3 85,34.66 84.86,34.66 84.77,34.57 84.77,34.44 85.13,34.08 85.13,33.95 85.03,33.86 84.9,33.86 84.55,34.21 84.41,34.21 83.89,33.69 83.73,33.69 83.63,33.6 83.63,32.64 83.54,32.55 83.41,32.55 83.32,32.64 83.32,33.6 83.22,33.69 83.09,33.69 83,33.6 83,32.64 82.91,32.55 82.77,32.55 82.68,32.64 82.68,33.6 82.59,33.69 80.66,33.69 79.71,32.74 61.07,32.74 60.99,32.82 60.5,32.82 59.22,34.1 56.46,34.1 56.37,34 56.37,33.48 56.27,33.39 56.14,33.39 56.05,33.48 56.05,34 55.96,34.1 55.58,34.1 54.98,33.5 49.69,33.5 49.14,32.95 46.64,32.95 46.28,33.31 v1(44.46,33.31)
PTD7/MII_RMII_TXD1//QSPI_A_IO1: length 42.6
  TOP w0.16: U7.44 v1(58.98,58.93) ; U8.52 v1(54.65,60.94)
  TOP w0.406: v1(43.19,42.23) 43.19,42.26 43.18,42.26 43.18,42.28 R224.1
  L3_INT_1 w0.191: 52.74,60.44 52.11,60.44 51.75,60.8 43.78,60.8 v1(39.1,56.12)
  L3_INT_1 w0.203: 52.74,60.44 52.94,60.44 53.25,60.74 53.73,60.74 53.93,60.94 v1(54.65,60.94)
  L6_INT_2 w0.191: v1(39.1,56.12) 39.7,56.12 42.49,53.33 42.49,50.09 43.85,48.73 43.85,42.89 v1(43.19,42.23)
  BOTTOM w0.16: v1(54.65,60.94) 55.19,60.94 57.2,58.93 v1(58.98,58.93)
PTD7/MII_RMII_TXD1//QSPI_A_IO1_: length 7.5
  TOP w0.279: U14.5 40.34,36.39 40.59,36.14 40.59,35.71 v1(40.96,35.34) 41.85,35.34 42.23,34.96 R271.1 R272.1
  BOTTOM w0.279: v1(40.96,35.34) 42.23,35.34 R272.1
PTD7/MII_RMII_TXD1//QSPI_A_IO_1: length 3.5
  TOP w0.279: v1(40.98,41.45) 40.61,41.08 40.58,41.08 40.34,40.85 U14.10
  TOP w0.406: R224.2 41.41,41.69 41.15,41.43 41.15,41.45 v1(40.98,41.45)
  BOTTOM w0.406: v1(40.98,41.45) 41.07,41.45 R573.2
PTD7/QSPI_A_IO1: length 48.1
  TOP w0.406: v1(42.23,32.55) R271.2
  BOTTOM w0.254: v1(42.23,32.55) 42.74,32.04 45.28,32.04 45.66,32.42 46.19,32.42 46.31,32.53 46.31,33.1 46.42,33.21 46.57,33.21 46.69,33.1 46.69,32.53 46.8,32.42 46.96,32.42 47.07,32.53 47.07,33.1 47.18,33.21 47.34,33.21 47.45,33.1 47.45,32.53 47.56,32.42 47.72,32.42 47.83,32.53 47.83,33.1 47.94,33.21 48.1,33.21 48.21,33.1 48.21,32.53 48.32,32.42 48.48,32.42 48.59,32.53 48.59,33.1 48.7,33.21 48.86,33.21 48.97,33.1 48.97,32.53 49.08,32.42 49.24,32.42 49.35,32.53 49.35,33.1 49.46,33.21 49.62,33.21 49.73,33.1 49.73,32.53 49.85,32.42 50.23,32.42 50.48,32.17 50.48,31.46 50.23,31.2 49.85,31.2 49.73,31.31 49.73,31.93 49.62,32.04 49.46,32.04 49.35,31.93 49.35,31.31 49.24,31.2 49.08,31.2 48.97,31.31 48.97,31.93 48.86,32.04 48.7,32.04 48.59,31.93 48.59,31.31 48.48,31.2 48.32,31.2 48.21,31.31 48.21,31.93 48.1,32.04 47.94,32.04 47.83,31.93 47.83,31.31 47.72,31.2 47.56,31.2 47.45,31.31 47.45,31.93 47.34,32.04 47.18,32.04 47.07,31.93 47.07,31.31 46.96,31.2 46.8,31.2 46.69,31.31 46.69,31.93 46.57,32.04 46.42,32.04 46.31,31.93 46.31,31.31 46.19,31.2 45.66,31.2 45.55,31.31 45.55,31.55 45.44,31.66 45.28,31.66 45.17,31.55 45.17,31.31 45.06,31.2 44.9,31.2 44.79,31.31 44.79,31.55 44.68,31.66 44.52,31.66 44.41,31.55 44.41,31.31 44.3,31.2 44.14,31.2 44.03,31.31 44.03,31.55 43.92,31.66 43.76,31.66 43.65,31.55 43.65,31.31 43.54,31.2 43.38,31.2 43.27,31.31 43.27,31.55 43.15,31.66 43,31.66 42.89,31.55 42.89,31.31 42.77,31.2 42.62,31.2 42.5,31.31 42.5,31.55 42.39,31.66 42.23,31.66 42.12,31.55 42.12,31.31 42.01,31.2 41.85,31.2 41.74,31.31 41.74,31.55 41.63,31.66 41.47,31.66 41.36,31.55 41.36,31.31 41.25,31.2 41.09,31.2 40.98,31.31 40.98,31.55 40.87,31.66 40.71,31.66 40.6,31.55 40.6,31.31 40.49,31.2 40.33,31.2 40.22,31.31 40.22,31.55 40.11,31.66 39.95,31.66 39.84,31.55 39.84,31.31 39.73,31.2 38.62,31.2 38.11,31.71 38.11,36.23 R585.1
PTD8/MII_RXD3: length 104.6
  TOP w0.406: R58.2 v1(103.61,72.6) ; R197.2 v1(44.39,50.26)
  L6_INT_2 w0.191: v1(44.39,50.26) 44.39,49.79 44.54,49.64 44.54,47.67 45.95,46.26 46.08,46.26 46.83,47.01 46.96,47.01 47.05,46.91 47.05,46.78 46.31,46.04 46.31,45.91 46.4,45.81 46.53,45.81 47.28,46.56 47.41,46.56 47.5,46.47 47.5,46.33 46.76,45.59 46.76,45.46 46.85,45.36 46.98,45.36 47.73,46.11 47.86,46.11 47.95,46.02 47.95,45.89 47.2,45.14 47.2,45.01 51.09,41.13 55.7,41.13 56.29,41.71 83.74,41.71 87.62,45.59 87.62,51.48 94.11,57.97 96.52,57.97 98.31,59.76 98.31,60.56 94.78,64.09 94.78,66.74 94.37,67.14 94.37,72.39 94.33,72.43 94.33,72.83 94.37,72.87 v1(94.37,73.8)
  BOTTOM w0.406: v1(94.37,73.8) 94.91,74.33 97.93,74.33 99.76,72.5 102.92,72.5 103.02,72.6 v1(103.61,72.6)
PTD8/MII_RXD3/QSPI_B_IO5: length 39.8
  TOP w0.16: U8.63 v1(54.18,55.43) ; U7.55 v1(59.45,53.43)
  TOP w0.406: v1(45.63,39.11) R232.1
  L3_INT_1 w0.191: v1(45.63,39.11) 44.84,38.32 42.72,38.32 42.11,38.93 42.11,41.91 41.6,42.42 41.6,47.81 42.36,48.58 42.36,49.86 47.93,55.43 52.74,55.43
  L3_INT_1 w0.203: v1(54.18,55.43) 52.74,55.43
  BOTTOM w0.16: v1(59.45,53.43) 57.37,53.43 55.37,55.43 v1(54.18,55.43)
PTD8/MII_RXD3/QSPI_B_IO5__A: length 3.4
  TOP w0.279: U13.12 45.55,42.13 v1(46.14,41.54) 45.63,41.03 R232.2
  BOTTOM w0.279: v1(46.14,41.54) 45.91,41.54 45.63,41.26 R232.2
PTD8/MII_RXD3/QSPI_B_IO5__B: length 3.9
  TOP w0.279: U13.3 45.55,47.34 v1(45.22,47.66) R197.1
  BOTTOM w0.279: v1(45.22,47.66) R197.1
PTD9/MII_RXD2: length 104.3
  TOP w0.406: v1(45.17,50.24) 45.17,50.24 45.17,50.25 45.17,50.25 45.17,50.25 45.4,50.02 R198.2 ; R62.2 v1(103.61,71.59)
  L6_INT_2 w0.191: v1(45.17,50.24) 45.17,49.25 49.68,44.74 49.68,44.6 49.12,44.05 49.12,43.91 49.22,43.82 49.35,43.82 49.91,44.38 50.04,44.38 50.13,44.29 50.13,44.15 49.57,43.6 49.57,43.47 49.67,43.37 49.8,43.37 50.35,43.93 50.49,43.93 50.58,43.84 50.58,43.71 50.02,43.15 50.02,43.02 50.11,42.92 50.25,42.92 50.8,43.48 50.94,43.48 51.03,43.39 51.03,43.26 50.47,42.7 50.47,42.57 50.56,42.47 50.7,42.47 51.25,43.03 51.38,43.03 51.48,42.94 51.48,42.81 50.92,42.25 50.92,42.12 51.01,42.03 51.14,42.03 51.7,42.58 51.83,42.58 51.93,42.49 51.93,42.36 51.37,41.8 51.37,41.67 51.46,41.58 51.59,41.58 52.15,42.13 52.28,42.13 52.95,41.47 55.56,41.47 56.14,42.05 83.6,42.05 87.3,45.76 87.3,51.61 93.98,58.28 96.07,58.28 96.51,58.72 96.51,59.92 94.41,62.01 94.41,65.97 94.04,66.35 94.04,69.65 93.76,69.92 v1(93.76,71.05)
  BOTTOM w0.406: v1(103.61,71.59) 99.42,71.59 97.34,73.67 95.21,73.67 94.75,73.21 94.27,73.21 93.76,72.71 v1(93.76,71.05)
PTD9/MII_RXD2/QSPI_B_IO4: length 27.7
  TOP w0.16: U7.54 v1(58.98,53.93) ; U8.62 v1(54.65,55.93)
  TOP w0.406: R233.1 47.33,39.86 v1(47.71,40.24)
  L3_INT_1 w0.191: v1(53.51,50.23) 48.91,45.63 48.91,41.44 v1(47.71,40.24)
  L6_INT_2 w0.191: v1(53.51,50.23) 53.51,55.43 54.01,55.93 v1(54.65,55.93)
  BOTTOM w0.16: v1(58.98,53.93) 57.5,53.93 55.5,55.93 v1(54.65,55.93)
PTD9/MII_RXD2/QSPI_B_IO4__A: length 4
  TOP w0.279: U13.13 46.05,42.53 46.54,42.03 46.86,42.03 v1(47.18,41.72) 47.06,41.6 47.06,41.29 R233.2
  BOTTOM w0.279: R233.2 46.65,41.34 47.03,41.72 v1(47.18,41.72)
PTD9/MII_RXD2/QSPI_B_IO4__B: length 3.7
  TOP w0.279: U13.2 46.05,46.96 45.99,47.01 v1(45.99,47.6) 45.96,47.6 45.96,47.94 R198.1
  BOTTOM w0.279: v1(45.99,47.6) 45.99,47.91 R198.1
PTD10/MII_RX_CLK: length 106
  TOP w0.406: R79.2 v1(103.16,68.54) ; R137.2 v1(102.63,58.63) ; R96.2 102.98,65.36 v1(102.68,65.06) ; R250.2 57.16,37.68 v1(57.63,37.21)
  L3_INT_1 w0.191: v1(103.16,68.54) 103.16,65.54 v1(102.68,65.06) 102.16,64.54 102.16,59.1 v1(102.63,58.63)
  L6_INT_2 w0.191: 83.93,39.13 85.34,39.13 89.84,43.64 89.84,47.17 91.14,48.47 91.14,48.49 92.47,49.82 92.47,49.95 92.22,50.2 92.22,50.34 92.32,50.43 92.45,50.43 92.7,50.18 92.83,50.18 92.92,50.27 92.92,50.4 92.67,50.65 92.67,50.78 92.76,50.88 92.9,50.88 93.15,50.63 93.28,50.63 93.37,50.72 93.37,50.85 93.12,51.1 93.12,51.23 93.21,51.33 93.34,51.33 93.59,51.08 93.73,51.08 94.48,51.83 94.48,53.59 95.05,54.17 95.18,54.17 95.93,53.42 96.06,53.42 96.16,53.51 96.16,53.64 95.41,54.39 95.41,54.52 95.5,54.62 95.63,54.62 96.38,53.86 96.51,53.86 96.61,53.96 96.61,54.09 95.86,54.84 95.86,54.97 95.95,55.06 96.08,55.06 96.83,54.31 96.96,54.31 97.06,54.41 97.06,54.54 96.3,55.29 96.3,55.42 96.4,55.51 96.53,55.51 97.28,54.76 97.41,54.76 97.5,54.86 97.5,54.99 96.75,55.74 96.75,55.87 96.85,55.96 96.98,55.96 97.73,55.21 97.86,55.21 97.95,55.3 97.95,55.44 97.2,56.19 97.2,56.32 97.3,56.41 97.43,56.41 98.18,55.66 98.31,55.66 98.4,55.75 98.4,55.89 97.65,56.64 97.65,56.77 99.52,58.63 100.93,58.63 101.02,58.54 101.02,57.54 101.12,57.44 101.25,57.44 101.34,57.54 101.34,58.54 101.44,58.63 101.57,58.63 101.66,58.54 101.66,57.54 101.75,57.44 101.88,57.44 101.98,57.54 101.98,58.54 102.07,58.63 v1(102.63,58.63) ; 82.84,38.62 82.17,37.95 76.06,37.95 74.12,36 70.72,36 69.45,37.27 68.91,37.27 68.81,37.36 68.81,37.7 68.72,37.8 68.59,37.8 68.5,37.7 68.5,37.36 68.4,37.27 68.27,37.27 68.18,37.36 68.18,37.7 68.09,37.8 67.95,37.8 67.86,37.7 67.86,37.36 67.77,37.27 67.64,37.27 67.54,37.36 67.54,37.7 67.45,37.8 67.32,37.8 67.23,37.7 67.23,37.36 67.13,37.27 67,37.27 66.91,37.36 66.91,37.7 66.82,37.8 66.68,37.8 66.59,37.7 66.59,37.36 66.5,37.27 66.19,37.27 65.85,36.92 65.72,36.92 65.11,37.53 64.98,37.53 64.89,37.44 64.89,37.31 65.49,36.7 65.49,36.57 65.4,36.47 65.27,36.47 64.66,37.08 64.53,37.08 64.44,36.99 64.44,36.86 65.04,36.25 65.04,36.12 64.95,36.03 64.82,36.03 64.21,36.63 64.08,36.63 63.99,36.54 63.99,36.41 64.59,35.8 64.59,35.67 63.97,35.04 63.14,35.04 62.86,35.32 62.86,35.51 60.57,37.8 60.22,37.8 60.13,37.9 60.13,37.99 60.04,38.08 59.91,38.08 59.81,37.99 59.81,37.9 59.72,37.8 59.59,37.8 59.49,37.9 59.49,37.99 59.4,38.08 59.27,38.08 59.18,37.99 59.18,37.9 59.08,37.8 58.95,37.8 58.86,37.9 58.86,37.99 58.77,38.08 58.64,38.08 58.54,37.99 58.54,37.9 58.45,37.8 58.23,37.8 v1(57.63,37.21)
  L6_INT_2 w0.203: 82.84,38.62 83.36,39.13 83.93,39.13
PTD10/MII_RX_CLK/QSPI_A_SCK: length 53.9
  TOP w0.16: U8.57 v1(54.18,58.43) ; U7.49 v1(59.45,56.43)
  TOP w0.406: v1(45.87,38.46) 45.87,38.46 46.11,38.69 R243.1
  L3_INT_1 w0.191: 52.74,58.43 47.86,58.43 46.97,57.55 46.52,57.55 42.18,53.2 40.98,53.2 39.62,51.84 39.62,51.17 39.16,50.71 39.16,48.27 39.33,48.1 39.33,41.66 39.42,41.57 39.42,39.82 42.19,37.05 42.64,37.05 45.16,34.54 46.14,34.54 46.96,35.35 46.96,36.6 46.42,37.14 46.42,37.94 45.9,38.46 v1(45.87,38.46)
  L3_INT_1 w0.203: 52.74,58.43 v1(54.18,58.43)
  BOTTOM w0.16: v1(59.45,56.43) 57.16,56.43 55.15,58.43 v1(54.18,58.43)
PTD10/MII_RX_CLK/QSPI_A_SCK__A: length 4
  TOP w0.229: U16.10 49.63,36.91 49.42,37.12 49.42,37.15 49.39,37.17 49.39,37.96 v1(48.86,38.49) 48.3,38.49 48.09,38.69
  BOTTOM w0.229: 48.09,38.69 48.3,38.49 v1(48.86,38.49)
PTD10/MII_RX_CLK/QSPI_A_SCK__B: length 5.1
  TOP w0.203: 55.59,38.62 R244.1
  TOP w0.279: R250.1 55.51,37.6 v1(54.65,37.6) 53.95,36.91 U16.5
  TOP w0.406: R250.1 55.59,38.62
  BOTTOM w0.406: R587.2 55.59,37.22 55.23,37.58 54.67,37.58 v1(54.65,37.6)
PTD10/QSPI_A_SCK: length 48.6
  TOP w0.203: v1(54.5,39.1) 54.84,39.44 55.86,39.44 R244.2
  L3_INT_1 w0.191: v1(36.89,34.4) 40.9,34.4 42.46,35.96 v1(42.46,36.43)
  L6_INT_2 w0.191: v1(42.46,36.43) 42.93,36.43 43.7,37.2 46.55,37.2 46.64,37.3 46.64,37.66 46.74,37.75 46.87,37.75 46.96,37.66 46.96,37.3 47.05,37.2 47.19,37.2 47.28,37.3 47.28,37.66 47.37,37.75 47.5,37.75 47.6,37.66 47.6,37.3 47.69,37.2 50.3,37.2 50.39,37.3 50.39,38.42 50.49,38.52 50.62,38.52 50.71,38.42 50.71,37.3 50.8,37.2 50.94,37.2 51.03,37.3 51.03,38.42 51.12,38.52 51.25,38.52 51.35,38.42 51.35,37.3 51.44,37.2 51.78,37.2 53.2,38.62
  L6_INT_2 w0.203: v1(54.5,39.1) 53.68,39.1 53.2,38.62
  BOTTOM w0.406: R591.1 23.15,36.28 22.75,35.88 22.75,34.02 23.15,33.61 30.41,33.61 31.4,32.62 33.03,32.62 33.46,32.19 36.49,32.19 36.89,32.6 v1(36.89,34.4)
PTD11/MII_RMII_TX_CLK: length 105.1
  TOP w0.279: v1(34.89,42.96) 35.57,42.96 36.6,43.99 36.88,43.99 R210.2
  TOP w0.406: R123.2 103.14,60.03 102.65,59.55 v1(102.64,59.55)
  L6_INT_2 w0.191: v1(102.64,59.55) 99.91,59.55 97.26,56.9 97.26,56.9 96.43,56.06 96.42,56.06 96.33,55.97 93.9,55.97 91.77,53.84 91.77,53.71 92.44,53.04 92.44,52.91 92.34,52.82 92.21,52.82 91.55,53.48 91.42,53.48 91.33,53.39 91.33,53.26 91.99,52.59 91.99,52.46 91.89,52.37 91.76,52.37 91.1,53.03 90.97,53.03 90.88,52.94 90.88,52.81 91.54,52.15 91.54,52.01 91.45,51.92 91.31,51.92 90.65,52.58 90.52,52.58 90.43,52.49 90.43,52.36 91.09,51.7 91.09,51.57 91,51.47 90.87,51.47 90.2,52.13 90.07,52.13 88.89,50.95 88.89,44.03 85.19,40.34 56.86,40.34 56.27,39.76 50.57,39.76 49.6,40.72 47.52,40.72 47.27,40.47 43.31,40.47 41.88,39.04 39.64,39.04 38.23,37.63 37.27,37.63 35.85,39.05 35.85,42 v1(34.89,42.96)
  BOTTOM w0.406: R514.2 103.68,64.46 104.41,63.74 104.41,60.34 103.62,59.55 v1(102.64,59.55)
PTD11/MII_RMII_TX_CLK/QSPI_A__1: length 76.8
  TOP w0.16: U8.56 v1(54.65,58.93) ; U7.48 v1(58.98,56.93)
  TOP w0.406: R141.2 v1(95.83,57.49) ; R173.1 v1(37.17,54.18)
  L3_INT_1 w0.191: v1(37.17,54.18) 37.51,53.84 41.92,53.84 46.89,58.81 52.62,58.81 52.74,58.93 ; v1(95.83,57.49) 95.83,57.97 93.94,59.86 84.4,59.86 v1(83.86,59.32)
  L3_INT_1 w0.203: v1(54.65,58.93) 52.74,58.93
  L6_INT_2 w0.191: v1(58.98,56.93) 70.54,56.93 75.51,61.9 76.19,61.9 77.3,63 78.18,63 78.85,63.67 78.85,64.86 79.13,65.14 81.4,65.14 82.29,64.25 82.84,64.25 84.99,62.1 84.99,60.45 v1(83.86,59.32)
  BOTTOM w0.16: v1(58.98,56.93) 57.16,56.93 55.16,58.93 v1(54.65,58.93)
PTD11/MII_RMII_TX_CLK/QSPI_A__2: length 3.6
  TOP w0.279: U11.3 v1(38.07,46.09) 38.07,45.42 R211.1 R210.1
  BOTTOM w0.279: v1(38.07,46.09) 38.07,45.42 R211.1
PTD11/MII_RMII_TX_CLK/QSPI_A_IO: length 3.8
  TOP w0.279: R173.2 37.61,51.97 37.78,51.97 v1(38.15,51.6) 38.16,51.6 38.16,51.6 38.07,51.5 U11.12
  BOTTOM w0.279: R173.2 37.61,51.97 37.78,51.97 v1(38.15,51.6)
PTD11/QSPI_A_IO0: length 49.1
  TOP w0.279: v1(36.82,43.47) 37.38,43.47 R211.2
  BOTTOM w0.254: R595.1 23.46,34.54 23.75,34.25 28.31,34.25 28.71,34.66 28.71,35.04 28.6,35.15 28.14,35.15 28.03,35.26 28.03,35.42 28.14,35.53 28.6,35.53 28.71,35.64 28.71,35.8 28.6,35.91 28.14,35.91 28.03,36.02 28.03,36.18 28.14,36.29 28.6,36.29 28.71,36.4 28.71,36.56 28.6,36.67 28.14,36.67 28.03,36.78 28.03,36.94 28.14,37.05 28.6,37.05 28.71,37.17 28.71,37.7 28.98,37.97 28.98,38.13 27.99,39.13 27.99,39.29 28.1,39.4 28.26,39.4 29.25,38.4 29.41,38.4 29.52,38.51 29.52,38.67 28.53,39.67 28.53,39.83 28.64,39.94 28.8,39.94 29.79,38.94 29.95,38.94 30.22,39.21 30.22,39.37 29.38,40.21 29.38,40.36 29.49,40.48 29.65,40.48 30.49,39.64 30.65,39.64 30.76,39.75 30.76,39.91 29.92,40.75 29.92,40.9 30.03,41.02 30.19,41.02 31.03,40.18 31.19,40.18 31.3,40.29 31.3,40.45 30.46,41.29 30.46,41.44 30.57,41.55 30.73,41.55 31.57,40.71 31.73,40.71 31.84,40.83 31.84,40.98 31,41.82 31,41.98 31.11,42.09 31.27,42.09 32.11,41.25 32.26,41.25 32.54,41.52 32.54,41.68 32.1,42.12 32.1,42.28 32.21,42.39 32.37,42.39 32.8,41.95 32.96,41.95 33.48,42.47 33.48,43.72 33.37,43.83 32.51,43.83 32.4,43.94 32.4,44.1 32.51,44.21 33.37,44.21 33.48,44.32 33.48,44.82 33.74,45.07 35.22,45.07 35.65,44.64 35.65,44.48 34.94,43.78 34.94,43.62 35.06,43.51 35.21,43.51 35.92,44.21 36.08,44.21 v1(36.82,43.47)
PTD12/MII_RMII_TX_EN: length 104.3
  TOP w0.406: R208.2 v1(34.26,44.28) ; v1(101.69,66.15) 102.81,66.15 103.16,66.51 R91.2
  L6_INT_2 w0.191: v1(34.26,44.28) 36.21,42.34 36.21,39.15 37.4,37.95 38.1,37.95 39.51,39.36 41.66,39.36 43.09,40.79 47.14,40.79 47.38,41.04 49.79,41.04 50.73,40.1 56.13,40.1 56.71,40.68 85.09,40.68 88.57,44.16 88.57,51.08 93.81,56.32 96.22,56.32 96.28,56.38 96.29,56.38 96.95,57.03 96.95,57.04 97.53,57.62 101.35,61.45 101.35,63.56 101.26,63.65 99.71,63.65 99.62,63.74 99.62,63.87 99.71,63.97 101.26,63.97 101.35,64.06 101.35,64.19 101.26,64.28 99.71,64.28 99.62,64.38 99.62,64.51 99.71,64.6 101.26,64.6 101.35,64.7 101.35,64.83 101.26,64.92 99.71,64.92 99.62,65.01 99.62,65.14 99.71,65.24 101.26,65.24 101.35,65.33 101.35,65.81 v1(101.69,66.15)
PTD12/MII_RMII_TX_EN/QSPI_A_I_1: length 4.4
  TOP w0.279: U11.13 37.57,51.33 v1(37.43,51.47) 37.07,51.83 36.74,51.83 R165.2
  BOTTOM w0.279: R165.2 36.74,51.83 37.07,51.83 v1(37.43,51.47)
PTD12/MII_RMII_TX_EN/QSPI_A_I_2: length 30.6
  TOP w0.16: U8.55 v1(54.18,59.43) ; U7.47 v1(59.45,57.43)
  TOP w0.406: v1(36.56,54.49) 36.16,54.09 R165.1
  L3_INT_1 w0.191: v1(36.56,54.49) 36.72,54.65 37.55,54.65 37.98,54.22 41.77,54.22 46.68,59.13 51.68,59.13 51.85,59.29 52.74,59.29
  L3_INT_1 w0.203: 52.74,59.29 53.29,59.29 53.43,59.43 v1(54.18,59.43)
  BOTTOM w0.16: v1(59.45,57.43) 57.14,57.43 55.14,59.43 v1(54.18,59.43)
PTD12/MII_RMII_TX_EN/QSPI_A_IO2: length 5.2
  TOP w0.279: R208.1 R209.1 v1(36.84,46.11) 37.36,46.11 37.57,46.32 U11.2
  BOTTOM w0.406: R566.2 37.5,46.57 37.3,46.57 v1(36.84,46.11)
PTD12/QSPI_A_IO2: length 48.1
  TOP w0.279: R209.2 35.27,43.52 v1(34.28,43.52)
  BOTTOM w0.254: v1(34.28,43.52) 34.28,42.63 33.49,41.84 33.49,41.69 34.63,40.55 34.63,40.39 34.52,40.28 34.36,40.28 33.22,41.42 33.06,41.42 32.79,41.15 32.79,40.99 33.79,39.99 33.79,39.83 33.68,39.72 33.52,39.72 32.52,40.72 32.37,40.72 31.27,39.63 31.27,39.47 31.97,38.78 31.97,38.62 31.85,38.51 31.7,38.51 31,39.2 30.84,39.2 29.35,37.7 29.35,36.48 29.46,36.37 30.99,36.37 31.1,36.26 31.1,36.1 30.99,35.99 29.46,35.99 29.35,35.87 29.35,35.72 29.46,35.61 30.99,35.61 31.1,35.49 31.1,35.34 30.99,35.22 29.46,35.22 29.35,35.11 29.35,34.4 29.6,34.15 31.07,34.15 31.32,33.89 31.32,33.58 31.43,33.47 31.59,33.47 31.7,33.58 31.7,34.04 31.81,34.15 32.19,34.15 32.3,34.04 32.3,33.19 32.42,33.08 32.57,33.08 32.69,33.19 32.69,34.04 32.8,34.15 32.95,34.15 33.07,34.04 33.07,33.19 33.18,33.08 33.34,33.08 33.45,33.19 33.45,34.04 33.56,34.15 33.94,34.15 34.05,34.04 34.05,32.76 34.16,32.65 34.32,32.65 34.43,32.76 34.43,34.04 34.54,34.15 34.7,34.15 34.81,34.04 34.81,32.76 34.93,32.65 35.08,32.65 35.19,32.76 35.19,34.04 35.58,34.42 35.73,34.42 35.94,34.21 36.1,34.21 36.21,34.33 36.21,34.48 36,34.69 36,34.85 36.79,35.63 R590.1
PTD13/FTM2_CH4/LPUART1_RX/ENET_: length 139.5
  TOP w0.16: U7.35 60.29,62.39 v1(61.05,61.63) ; U8.42 v1(58.78,67.57)
  TOP w0.406: v1(86.09,35.14) 87.01,34.22 89.57,34.22 90.79,33.01 96.79,33.01 98.26,31.53 98.26,27.24 97.65,26.63 J5.20 ; R317.1 v1(50.51,12.35)
  L3_INT_1 w0.191: v1(50.51,12.35) 51.64,11.22 82.12,11.22 96.48,25.58 J5.20 ; v1(86.09,35.14) 86.09,43.9 85.41,44.58 85.41,46.69 85.83,47.11 85.83,47.5 85.43,47.91 85.43,51.97 83.93,53.47
  L3_INT_1 w0.203: v1(58.78,67.57) 58.78,67.09 61.27,64.6 78.06,64.6 80.91,61.75 80.91,56.77 82.49,55.19 82.65,55.19 82.93,54.91 82.93,54.47 83.93,53.47
  BOTTOM w0.16: v1(58.78,67.57) 58.78,65.6 60.29,64.09 60.29,62.85 61.05,62.09 v1(61.05,61.63)
PTD14/FTM2_CH5/LPUART1_TX/ENET_: length 124.4
  TOP w0.16: U7.34 v1(60.79,63.24) ; U8.41 v1(59.28,68.04)
  TOP w0.406: R322.1 v1(63.21,12.33)
  L3_INT_1 w0.191: v1(82.89,30.74) 86.57,34.42 86.57,41.84 86.43,41.98 86.43,48.2 86.72,48.49 86.72,51.27 83.93,54.06
  L3_INT_1 w0.203: v1(59.28,68.04) 59.28,67.39 61.72,64.96 78.21,64.96 81.34,61.82 81.34,56.84 82.64,55.55 82.79,55.55 83.29,55.06 83.29,54.71 83.93,54.06
  L6_INT_2 w0.191: 56.95,67.63 56.43,67.63 56.1,67.95 54.41,67.95 54.07,68.29 51.87,68.29 45.68,74.48 J1.22
  L6_INT_2 w0.203: v1(59.28,68.04) 59.27,68.06 58.51,68.06 58.08,67.63 56.95,67.63
  BOTTOM w0.16: v1(60.79,63.24) 60.79,64.35 59.28,65.86 v1(59.28,68.04)
  BOTTOM w0.406: v1(63.21,12.33) 64.27,11.26 75.96,11.26 82.48,17.78 82.48,30.33 v1(82.89,30.74)
PTD15/FTM0_CH0/TRACE_D3/LPSPI0_: length 202.7
  TOP w0.16: U8.36 v1(61.79,67.57) ; U7.29 v1(63.29,62.77)
  TOP w0.406: R332.1 v1(29.41,10.25) ; R148.2 v1(95.08,55.43)
  L3_INT_1 w0.191: v1(29.41,10.25) 81.65,10.25 96.92,25.52 96.94,25.52 97.59,26.17 97.59,26.19 97.75,26.35 97.75,38.4 100.9,41.55 100.9,41.94 100.62,42.22 98.67,42.22 95.26,45.64 93.77,45.64 93.2,46.21 93.2,52.91 93.36,53.08 93.38,53.08 93.66,53.36 93.66,53.37 95.08,54.8 v1(95.08,55.43) 96.4,56.75 96.4,60.34 96.31,60.43 96.31,61.27 97.19,62.15 97.35,62.15 98.13,62.92 98.13,71.28 96.22,73.19 92.93,73.19 85.99,66.25 83.93,66.25
  L3_INT_1 w0.203: 83.93,66.25 82.64,66.25 81.7,65.31 63.56,65.31 61.79,67.09 v1(61.79,67.57)
  L6_INT_2 w0.191: 60.97,69.05 60.86,69.15 58.16,69.15 58.06,69.05 ; J1.19 46.96,76.17 46.96,73.65 51.97,68.63 52.74,68.63
  L6_INT_2 w0.203: v1(61.79,67.57) 61.79,68.23 60.97,69.05 ; 58.06,69.05 57.37,68.36 54.49,68.36 54.22,68.63 52.74,68.63
  BOTTOM w0.16: v1(63.29,62.77) 63.29,64.8 61.79,66.31 v1(61.79,67.57)
PTD16/FTM0_CH1/TRACE_D2/LPSPI0_: length 94.2
  TOP w0.16: U8.35 v1(62.29,68.04) ; U7.28 v1(63.79,63.24)
  TOP w0.406: v1(96.79,61.07) 96.56,61.3 R114.2
  L3_INT_1 w0.191: 83.93,66.71 86,66.71 93.57,74.28 95.57,74.28 98.44,71.41 98.44,62.73 v1(96.79,61.07)
  L3_INT_1 w0.203: 83.93,66.71 82.44,66.71 81.39,65.67 64.01,65.67 62.29,67.39 v1(62.29,68.04)
  L6_INT_2 w0.191: 52.74,67.94 51.77,67.94 44.58,75.13 44.58,77.88 45.23,78.53 49.66,78.53 J1.16
  L6_INT_2 w0.203: 52.74,67.94 53.93,67.94 54.26,67.6 55.96,67.6 56.47,67.09 61.99,67.09 62.29,67.39 v1(62.29,68.04)
  BOTTOM w0.16: v1(63.79,63.24) 63.79,64.78 62.29,66.29 v1(62.29,68.04)
PTD17/FTM0_FLT2/LPUART2_RX/FTM5: length 25
  TOP w0.16: U8.32 v1(63.79,67.57) ; U7.25 v1(65.29,62.77)
  L3_INT_1 w0.191: v1(63.79,67.57) 63.79,69.3 63.89,69.4 v1(63.89,71.08)
  L6_INT_2 w0.191: J1.13 56.52,74.21 57.48,74.21 60.61,71.08 v1(63.89,71.08)
  BOTTOM w0.16: v1(63.79,67.57) 63.79,66.27 65.29,64.77 v1(65.29,62.77)
PTD18/FTM5_CH7/FXIO_D2/LPI2C1_S: length 95.9
  TOP w0.16: U7.88 v1(67.29,44.59) ; 66.79,40.98 v1(66.79,39.79)
  TOP w0.406: v1(67.4,30.44) 67.4,29.75 67.32,29.67 67.32,23.69 61.41,17.78 v1(60.68,17.78) ; R321.1 v1(60.67,12.37)
  L3_INT_1 w0.191: v1(60.68,17.78) 60.68,12.86 60.67,12.85 v1(60.67,12.37) ; 66.79,38.62 67.4,38.01 v1(67.4,30.44) ; v1(80.2,75.88) 77.71,75.88 J6.19
  L3_INT_1 w0.203: 66.79,38.62 v1(66.79,39.79)
  BOTTOM w0.16: v1(66.79,39.79) 66.79,39.92 67.29,40.42 v1(67.29,44.59)
  BOTTOM w0.203: v1(80.2,75.88) 80.2,75.4 81.52,74.08 86.84,74.08 87.87,73.04 87.87,67.41 87.85,67.39 87.85,57.46 82.9,52.51 81.85,52.51 79.75,50.41 77.9,50.41 76.34,48.85 70.03,48.85 67.29,46.12 v1(67.29,44.59)
PTD19/FTM6_CH0/FXIO_D3/LPI2C1_S: length 141.2
  TOP w0.16: 67.29,40.98 v1(67.29,39.32) ; U7.89 v1(67.79,44.12)
  TOP w0.406: R314.1 v1(42.89,12.35)
  L3_INT_1 w0.191: v1(66,83.22) 66.4,83.62 71.54,83.62 72.51,82.65 72.51,78.54 J6.22
  L3_INT_1 w0.203: v1(67.29,39.32) 67.29,39.97 66.99,40.27 53.99,40.27 v1(52.92,39.2)
  L6_INT_2 w0.191: 52.74,63.01 48.5,58.77 46.85,58.77 46.3,58.22 46.3,49.09 53.23,42.16 55.28,42.16 55.95,42.83 57.96,42.83
  L6_INT_2 w0.203: 57.96,42.83 66.5,42.83 v1(67.79,44.12) ; v1(53.27,63.05) 52.78,63.05 52.74,63.01
  BOTTOM w0.16: v1(67.29,39.32) 67.29,39.94 67.79,40.44 v1(67.79,44.12)
  BOTTOM w0.203: v1(53.27,63.05) 53.27,63.54 53.12,63.68 53.12,67.47 54.37,68.72 54.37,69.05 ; 52.92,38.62 v1(52.92,39.2)
  BOTTOM w0.406: 52.92,38.62 52.92,35.24 52.08,34.4 52.08,26.23 51.19,25.33 50.04,25.33 47.76,23.06 47.76,17.23 v1(42.89,12.35) ; 54.37,69.05 54.37,73.53 56.38,75.53 56.38,75.93 57.06,76.62 57.06,80.36 57.97,81.27 64.05,81.27 v1(66,83.22)
PTD20/FTM6_CH1: length 64.9
  TOP w0.203: 69.79,40.98 69.79,39.53 69.89,39.43 v1(69.89,38.77)
  L3_INT_1 w0.191: v1(53.4,45.68) 53.38,45.68 53.4,45.65 53.4,45.49 54.45,44.45 54.8,44.45 55.32,43.92 55.32,43.41 58.01,40.72 68.56,40.72 69.89,39.4 v1(69.89,38.77)
  BOTTOM w0.203: v1(53.4,45.68) 53.06,46.02 53.04,46.02 50.26,48.8 50.26,49.51 49.19,50.58 49.19,52.46 44.08,57.57 44.08,59.95 42.71,61.33 42.71,73.37 43.81,74.47 43.81,80.64 J1.24
PTD21/FTM6_CH2: length 65.3
  TOP w0.203: 71.79,40.98 v1(71.79,39.23)
  L3_INT_1 w0.191: v1(49.2,66.96) 50.38,66.96 52.39,64.96 54.77,64.96 55.66,64.07 55.66,43.55 58.11,41.11 70.65,41.11 71.79,39.96 v1(71.79,39.23)
  BOTTOM w0.191: J1.21 47.11,81.4 47.11,76.4 49.36,74.14 49.36,67.6 49.2,67.44 v1(49.2,66.96)
PTD22/FTM6_CH3/FTM6_CH3/ADC1_SE: length 36.9
  TOP w0.16: 73.3,40.98 v1(73.3,39.79) ; U7.99 v1(72.79,44.12)
  L3_INT_1 w0.191: 73.3,38.62 70.5,35.82 70.5,29.57 68.68,27.75 56.74,27.75 56.45,28.05 54.72,28.05 J4.5
  L3_INT_1 w0.203: 73.3,38.62 v1(73.3,39.79)
  BOTTOM w0.16: v1(72.79,44.12) 72.79,41.18 73.3,40.67 v1(73.3,39.79)
PTD23/FTM6_CH4/FTM6_CH4/ADC1_SE: length 38.1
  TOP w0.16: 75.3,40.98 v1(75.3,39.79) ; U7.103 v1(74.79,44.12)
  L3_INT_1 w0.191: J4.8 57.26,25.21 69.13,25.21 71.22,27.31 71.22,35.46 74.38,38.62
  L3_INT_1 w0.203: 74.38,38.62 74.78,38.62 75.3,39.14 v1(75.3,39.79)
  BOTTOM w0.16: v1(75.3,39.79) 75.3,41.97 74.79,42.48 v1(74.79,44.12)
PTD24/FTM6_CH5/FTM6_CH5/ADC1_SE: length 40.1
  TOP w0.16: U7.106 76.29,44.33 76.11,44.51 v1(76.11,44.97) ; 76.8,40.98 v1(76.8,39.32)
  L3_INT_1 w0.191: 76.1,38.62 75.23,37.75 73.96,37.75 71.54,35.33 71.54,25.82 v1(71.18,25.46)
  L3_INT_1 w0.203: v1(76.8,39.32) 76.1,38.62
  L6_INT_2 w0.191: v1(71.18,25.46) 69.39,25.46 69.13,25.2 59.81,25.2 J4.11
  BOTTOM w0.16: v1(76.8,39.32) 76.8,42.5 76.29,43.01 76.29,44.33 76.11,44.51 v1(76.11,44.97)
PTD25/FTM6_CH6: length 96.5
  TOP w0.203: v1(79.38,39.68) 79.3,39.68 79.3,40.98
  L3_INT_1 w0.191: v1(20.38,76.19) 20.86,76.19 20.94,76.26 23.66,76.26 27.06,72.86 45.04,72.86 52.6,65.31 52.74,65.31
  L3_INT_1 w0.203: 52.74,65.31 54.92,65.31 56.01,64.21 56.01,43.7 58.2,41.51 77.56,41.51 v1(79.38,39.68)
  L6_INT_2 w0.191: J2.24 22.44,81.11 20.87,81.11 20.05,80.29 20.05,76.52 v1(20.38,76.19)
PTD26/FTM6_CH7/FXIO_D7: length 93.7
  TOP w0.203: v1(83.45,43.57) 82.97,43.57 82.87,43.47 82.69,43.47 82.64,43.42 U8.134
  L3_INT_1 w0.191: v1(43.01,81.39) 44.16,80.25 44.16,77.4 46.24,75.32 47.63,75.32 47.66,75.29 48.42,75.29 50.42,73.29 52.5,73.29 55.01,70.78 55.01,69.74 55.7,69.05
  L3_INT_1 w0.203: v1(83.45,43.57) 83.88,44 83.88,51.39 82.92,52.36 82.37,52.36 80.25,54.48 80.25,55.72 77.15,58.82 77.15,60.92 77.46,61.23 77.46,61.63 77.15,61.94 77.15,62.91 77.27,63.04 77.27,63.44 76.82,63.89 60.89,63.89 56.24,68.54 56.21,68.54 55.7,69.05
  L6_INT_2 w0.191: v1(43.01,81.39) 43.01,82.84 42.25,83.61 22.4,83.61 J2.27
PTD27/FTM7_CH0/FTM7_CH0/ADC1_SE: length 43.6
  TOP w0.16: U7.110 77.94,45.43 77.78,45.59 77.57,45.59 77.25,45.91 77.25,45.96 v1(76.92,46.29) ; U8.135 v1(82.44,43.92)
  BOTTOM w0.16: v1(76.92,46.29) 76.92,46.24 77.05,46.12 77.05,46.07 77.68,45.43 78.7,45.43 80.2,43.92 v1(82.44,43.92)
  BOTTOM w0.191: J4.14 62.29,28 62.29,29.55 64.04,31.3 67.78,31.3 68.34,31.86 70.4,31.86 76.07,37.54 78.39,37.54 80.2,39.34 80.2,39.63 83.95,43.38 83.95,43.84 83.74,44.05 83.25,44.05 83.13,43.92 v1(82.44,43.92)
PTD28/FTM7_CH1/FTM7_CH1/ADC1_SE: length 40
  TOP w0.16: U8.137 v1(82.44,44.92) ; U7.112 v1(77.63,46.43)
  BOTTOM w0.16: v1(82.44,44.92) 80.98,44.92 79.47,46.43 v1(77.63,46.43)
  BOTTOM w0.191: v1(82.44,44.92) 83.42,44.92 84.28,44.07 84.28,43.22 80.54,39.48 80.54,39.2 78.56,37.22 76.24,37.22 70.55,31.53 68.82,31.53 68.26,30.97 66.25,30.97 64.9,29.62 64.9,28.07 J4.17
PTD29/FTM7_CH2/FTM7_CH2/ADC1_SE: length 60.8
  TOP w0.16: v1(82.44,45.9) 82.44,45.92 U8.139 ; U7.114 v1(77.63,47.43)
  L3_INT_1 w0.191: v1(89.45,55.18) 89.8,54.82 v1(93.43,54.82)
  L6_INT_2 w0.191: v1(89.45,55.18) 89.45,54.65 86.39,51.6 86.39,50.26 86.11,49.98 85.85,49.98 85.5,49.64 85.5,49.1 84.14,47.74 84.14,46.65 83.93,46.45
  L6_INT_2 w0.203: v1(82.44,45.9) 83.39,45.9 83.93,46.45
  BOTTOM w0.16: v1(82.44,45.9) 81.15,45.9 79.62,47.43 v1(77.63,47.43)
  BOTTOM w0.191: J4.20 67.44,28.07 67.44,29.62 68.13,30.31 69.78,30.31 76.3,36.84 78.66,36.84 80.88,39.06 80.88,39.28 84.59,42.99 84.59,44.41 83.1,45.9 v1(82.44,45.9)
  BOTTOM w0.406: v1(93.43,54.82) 93.85,54.41 93.85,53.04 94.63,52.26 R549.1
PTD30/FTM7_CH3/FTM6_FLT1/ADC1_S: length 46.9
  TOP w0.16: U8.141 82.43,46.93 v1(82.44,46.92) ; U7.116 v1(77.63,48.43)
  BOTTOM w0.16: v1(77.63,48.43) 79.76,48.43 81.27,46.92 v1(82.44,46.92)
  BOTTOM w0.191: J4.23 71.51,29.6 71.51,30.7 74.68,33.87 78.54,33.87 79.32,34.66 84.04,34.66 87.92,38.54 87.92,45.42 85.55,47.78 84.44,47.78 84.16,47.51 83.02,47.51 v1(82.44,46.92)
PTD31/FTM7_CH4/FXIO_D6/FTM6_FLT: length 101
  TOP w0.203: v1(85.36,47.31) 84.87,47.31 84.85,47.33 84.44,47.33 84.36,47.41 82.24,47.41 82.23,47.43 U8.142
  L3_INT_1 w0.191: v1(40.28,61.08) 39.81,61.08 39.74,61.15 34.36,61.15 31.71,63.8 31.21,63.8 27.77,67.23 27.77,69.09 22.07,74.79 20.38,74.79 18.96,76.21 18.42,76.21 17.66,76.97 17.66,81.41 J2.30
  L6_INT_2 w0.191: v1(85.36,47.31) 85.36,44.79 82.97,42.4 56,42.4 55.42,41.81 53.09,41.81 45.83,49.07 45.83,55.36 40.62,60.57 40.62,60.75 v1(40.28,61.08)
PTE0/LPSPI0_SCK/TCLK1/LPI2C1_SD: length 62.1
  TOP w0.16: U8.166 v1(82.44,59.43)
  TOP w0.203: U7.138 80.25,59.43 80.25,59.43 U8.166
  TOP w0.406: R328.1 v1(78.45,12.33) 78.45,13.68 J5.16
  L3_INT_1 w0.191: 83.93,58.57 84.25,58.25 84.8,58.25 91.35,51.7 91.35,42.72 92.65,41.42 92.65,27.87 J5.16
  L3_INT_1 w0.203: 83.93,58.57 83.34,59.16 83.34,59.19 83.09,59.43 v1(82.44,59.43)
PTE1/LPSPI0_SIN/LPI2C0_HREQ/LPI: length 60.4
  TOP w0.16: U8.165 v1(82.91,58.93)
  TOP w0.203: U7.137 80.25,58.93 80.25,58.93 U8.165
  TOP w0.406: R327.1 v1(75.91,12.33) 75.91,13.68 J5.14
  L3_INT_1 w0.191: J5.14 89.96,27.73 89.96,28.7 89.97,28.71 89.97,29.63 89.96,29.64 89.96,48.47 88.96,49.46 88.96,53.64 84.7,57.91 83.93,57.91
  L3_INT_1 w0.203: 83.93,57.91 v1(82.91,58.93)
PTE2/LPSPI0_SOUT/FTM3_CH6/SAI1_: length 129
  TOP w0.203: U7.122 80.25,51.43 80.25,51.43 U8.150 82.27,51.43 v1(82.72,51.88)
  TOP w0.406: R316.1 v1(47.97,12.54) 48.75,13.32 54.09,13.32 54.95,14.18 62.88,14.18 74.11,25.41 74.13,25.41 74.84,26.12 74.84,27.13 74.83,27.15 74.83,28.16 74.84,28.17 74.84,30.01 75.53,30.69 v1(79.59,30.69)
  L3_INT_1 w0.191: v1(79.59,30.69) 80.88,31.98 80.88,32.9 82.23,34.25 82.23,36.45 83.69,37.92 83.69,38.62
  L3_INT_1 w0.203: 83.69,38.62 83.69,40.82 81.61,42.91 81.61,50.77 v1(82.72,51.88)
  L6_INT_2 w0.191: J1.17 51.86,81.07 53.76,81.07 54.74,80.09 54.74,76.98 56.87,74.85 57.73,74.85 57.73,74.85 57.74,74.85 60.71,71.87 64.31,71.87 66.41,69.77 72.53,69.77 73.09,69.22 81.69,69.22 85.35,65.56 85.35,65.53 85.95,64.93 85.95,64.92 85.95,55.12
  L6_INT_2 w0.203: 85.95,55.12 v1(82.72,51.88)
PTE3/FTM0_FLT0/FTM2_FLT0/CMP0_O: length 28.4
  TOP w0.16: U8.28 v1(65.79,67.57) ; U7.21 v1(67.29,62.77)
  L3_INT_1 w0.191: v1(65.79,67.57) 65.79,69.69 v1(65.37,70.11)
  L6_INT_2 w0.191: J1.14 54.42,78.85 54.42,76.85 56.73,74.53 57.59,74.53 57.6,74.53 57.61,74.53 60.58,71.56 64.09,71.56 65.03,70.62 65.03,70.45 v1(65.37,70.11)
  BOTTOM w0.16: v1(67.29,62.77) 67.29,64.77 65.79,66.27 v1(65.79,67.57)
PTE4/CAN0_RX_LS: length 12.2
  TOP w0.203: v1(19.37,61.5) 19.57,61.71 TP13.1 20.66,61.17 R127.1
  L3_INT_1 w0.203: v1(19.37,61.5) 19.37,61.18 18.88,60.69 17.83,60.69 16.17,59.03 v1(16.17,56.2)
  BOTTOM w0.203: v1(16.17,56.2) 16.42,56.2 16.76,56.54 16.76,57.38 16.44,57.7 U502.6
PTE4/TRACE_D1/FTM2_CH2/CAN0_RX/: length 114.8
  TOP w0.16: U7.9 v1(73.29,62.77) ; U8.15 v1(72.29,68.04)
  TOP w0.406: R136.2 v1(95.87,58.76)
  L6_INT_2 w0.191: v1(46.11,66.51) 46.11,65.34 44.91,64.14 42.65,64.14 42.14,64.65 30.29,64.65 26.21,68.74 24.89,68.74 24.39,68.24 24.39,66.36 21.13,63.1 17.35,63.1 v1(16.84,62.6) ; v1(95.87,58.76) 81.5,73.14 v1(75.76,73.14) ; 61.65,69.78 61.33,70.11 58.59,70.11 57.35,71.35 54,71.35 53.56,70.91 52.15,70.91 49.73,73.33 v1(48.55,73.33)
  L6_INT_2 w0.203: 61.65,69.78 63.13,69.78 64.15,68.77 71.57,68.77 v1(72.29,68.04)
  BOTTOM w0.16: v1(72.29,68.04) 72.29,65.55 73.29,64.55 v1(73.29,62.77)
  BOTTOM w0.191: v1(46.11,66.51) 47.08,66.51 48.67,68.1 48.67,68.1 48.99,68.42 48.99,68.42 49.05,68.47 49.05,72.83 v1(48.55,73.33)
  BOTTOM w0.203: 72.29,69.05 v1(72.29,68.04) ; R520.1 16.8,62.24 16.8,62.6 v1(16.84,62.6)
  BOTTOM w0.406: 72.29,69.05 72.29,69.68 v1(75.76,73.14)
PTE5/CAN0_TX_LS: length 9.8
  TOP w0.203: R126.1 19.23,60.83 19.02,60.83 v1(18.68,61.17)
  L3_INT_1 w0.203: v1(15.46,56.47) 15.46,58.79 17.84,61.17 v1(18.68,61.17)
  BOTTOM w0.203: U502.7 TP504.1 v1(15.46,56.47)
PTE5/TCLK2/FTM2_CH3/CAN0_TX/FXI: length 81.9
  TOP w0.16: U7.8 v1(73.79,63.24) ; U8.14 v1(72.8,67.57)
  TOP w0.406: v1(37.3,72.04) 37.3,75.15 38.2,76.05 40.43,76.05 41.64,74.84 v1(47.43,74.84)
  L6_INT_2 w0.191: v1(37.3,72.04) 37.3,71.57 36.07,70.34 25.35,70.34 23.03,68.02 23.03,65.9 21.05,63.92 16.73,63.92 14.67,61.86 v1(13.4,61.86) ; v1(47.43,74.84) 47.82,74.45 47.82,74.34 48.35,73.8 50.19,73.8 52.77,71.23 53.43,71.23 53.87,71.67 57.54,71.67 58.78,70.43 61.46,70.43 61.78,70.11 63.3,70.11 64.29,69.12 71.9,69.12 71.97,69.05
  L6_INT_2 w0.203: 71.97,69.05 72.8,68.23 v1(72.8,67.57)
  BOTTOM w0.16: v1(73.79,63.24) 73.79,64.81 72.8,65.81 v1(72.8,67.57)
  BOTTOM w0.203: v1(13.4,61.86) 13.65,62.11 R519.1
PTE6/LPSPI0_PCS2/FTM7_FLT1/FTM3: length 57.6
  TOP w0.203: v1(83.25,51.32) 82.72,51.32 82.33,50.93 U8.149 80.25,50.93 80.25,50.93 U7.121
  L6_INT_2 w0.191: J1.11 56.94,78.87 56.94,76.09 57.86,75.16 57.87,75.16 60.84,72.19 64.44,72.19 66.54,70.09 72.66,70.09 73.15,69.61 82.05,69.61 82.61,69.05 ; 83.93,67.73 86.28,65.38 86.28,54.86 83.93,52.51
  L6_INT_2 w0.203: v1(83.25,51.32) 83.25,51.83 83.93,52.51 ; 82.61,69.05 83.93,67.73
PTE7/FTM0_CH7/FTM3_FLT0: length 62.9
  TOP w0.16: 66.29,40.98 v1(66.29,39.32) ; U7.87 v1(66.79,44.12)
  L3_INT_1 w0.191: 55.2,69.05 53.1,71.15 v1(53.1,72.02)
  L3_INT_1 w0.203: v1(66.79,44.12) 66.79,44.78 66.45,45.12 64.44,45.12 60.21,49.35 60.21,55 60.4,55.19 60.4,55.67 60.27,55.8 60.27,63.98 56.07,68.18 56.06,68.18 55.2,69.05
  L6_INT_2 w0.191: v1(53.1,72.02) 52.19,72.93 52.19,78 51.34,78.86 50.32,78.86 49.66,79.51 49.66,80.42 50.62,81.39 56.97,81.39 J1.8
  BOTTOM w0.16: v1(66.79,44.12) 66.79,40.44 66.29,39.94 v1(66.29,39.32)
PTE8/FTM0_CH6/MII_RMII_MDC/CMP0: length 32.2
  TOP w0.16: U7.39 59.65,61.43 59.94,61.14 v1(59.74,61.14) ; v1(53.95,63.08) 53.96,63.08 53.96,63.28 54.12,63.44 U8.47
  BOTTOM w0.16: v1(59.74,61.14) 59.42,61.46 57.58,61.46 55.64,63.41 54.28,63.41 v1(53.95,63.08)
  BOTTOM w0.203: 54.9,69.05 54.9,68.54 53.48,67.12 53.48,64.04 53.95,63.57 v1(53.95,63.08)
  BOTTOM w0.406: 54.9,69.05 54.9,73.3 55.83,74.23 56.89,74.23 59.72,77.06 59.72,78.76 J1.5
PTE9/FTM0_CH7/LPUART2_CTS/ENET_: length 152.7
  TOP w0.16: U7.30 v1(62.79,63.24) ; U8.37 v1(61.29,68.04)
  TOP w0.406: R331.1 v1(26.12,11)
  L3_INT_1 w0.191: v1(26.12,11) 26.6,11 26.76,10.84 27.71,10.84 27.91,11.05 36.46,11.05 39.17,13.76 39.17,19.94 37.03,22.08 31.23,22.08 30.32,22.99 29.99,22.99 29.34,23.63 29.34,27.08 30,27.74 30.57,27.74 31.74,28.91 31.74,29.73 32.47,30.47 v1(32.47,31.51) ; J1.2 64.57,78.86 64.57,73.16 62.29,70.87 62.29,69.05
  L3_INT_1 w0.203: 62.29,69.05 v1(61.29,68.04)
  L6_INT_2 w0.191: v1(32.47,31.51) 32.02,31.96 32,31.96 19.67,44.29 19.67,48.57 17.33,50.92 16.95,50.92 12.85,55.02 12.85,57.82 13.4,58.37 15.47,58.37 17.45,60.36 22.52,60.36 22.87,60.71 22.89,60.71 23.17,60.99 23.17,61.38 23.15,61.4 23.15,61.7 25.47,64.02 41.87,64.02 42.39,63.5 50.02,63.5 50.59,64.08 52.56,64.08 52.74,63.89
  L6_INT_2 w0.203: v1(62.79,63.24) 62.31,63.72 54.98,63.72 54.77,63.51 54.37,63.51 53.98,63.89 52.74,63.89
  BOTTOM w0.16: v1(61.29,68.04) 61.29,66.33 62.79,64.83 v1(62.79,63.24)
