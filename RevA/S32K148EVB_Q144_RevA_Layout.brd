# Allegro board S32K148EVB_Q144_RevA_Layout.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
P3V3_ENET: length 9.9
  TOP w0.279: L4.2 119.79,59.2 119.68,59.31 R133.2 119.68,60.58 119.72,60.61 TPAD28.1 ; TPAD28.1 118.6,62.55 J16.3 ; TPAD28.1 118.68,61.43 118.06,62.05 J16.1
P3V3_ENETSW: length 34
  TOP w0.203: U3.8 100.78,54.89 100.62,55.05 v1(99.58,55.05) ; R185.1 94.75,52.03 94.34,51.61 U10.8 ; R201.1 99.28,47.29 99.98,46.58 U12.8
  TOP w0.508: R201.1 98.79,48.09 98.29,47.58 v1(98.29,47.25) ; R202.1 v1(104.84,48.09) ; R199.1 v1(96.79,47.71) ; R144.1 TPAD31.1
  TOP w0.635: R142.1 R144.1 ; R142.1 101.31,58.05 101.43,58.18 C19.1 C18.1 C17.1 ; R142.1 100.42,57.36 v1(100.06,57.72) ; v1(97.55,50.51) 96.94,51.12 96.94,51.55 96.46,52.03 R185.1
  BOTTOM w0.203: v1(97.55,50.51) 97.78,50.28 99.15,50.28 99.38,50.51 U505.8
  BOTTOM w0.635: R521.1 99.81,60.2 R522.1 99.83,58.65 100.06,58.42 v1(100.06,57.72) ; R551.1 v1(104.76,51.22) ; v1(104.84,48.09) 103.85,49.08 R556.1
P3V3_SDA: length 58.9
  TOP w0.229: R301.1 14.06,12.46 R308.1
  TOP w0.279: R308.1 v1(13.04,13.37)
  TOP w0.508: v1(17.08,20.81) 17.54,21.27 R285.2 ; R286.1 v1(25.79,20.97) ; v1(13.64,19.96) 12.8,19.96 12.79,19.95 11.32,19.95 10.95,19.58 R288.1 9.6,19.57 R291.1 ; v1(19.37,21.19) 19.8,20.76 U23.5 C97.1 ; R281.1 v1(13.77,22.95)
  TOP w0.635: TPAD48.1 34.89,21.19 TP55.1 33.74,21.02 v1(33.19,20.46)
  L4_PWR_1 w0.508: 21.6,27.89 J20.1 22.33,26.55
  BOTTOM w0.203: U509.1 v1(35.14,16.85)
  BOTTOM w0.279: v1(21.15,14.21) 21.15,14.01 21.43,13.72 U513.7 ; U510.7 14.47,18.15 14.01,18.61 14.01,19.07 13.64,19.44 v1(13.64,19.96) ; U510.11 16.74,19.96 16.68,20.02 16.68,20.41 v1(17.08,20.81) ; 30.67,14.65 v1(30.63,14.65) ; 30.67,14.65 U511.1 ; 30.67,14.65 30.58,14.74 R622.1 ; U510.1 14.44,15.15 13.98,14.69 v1(13.98,14.59) 13.96,14.62 C545.1 ; v1(17.87,8.09) R631.1
  BOTTOM w0.305: U512.1 26.64,15.06 26.4,15.3 25.78,15.3 v1(25.78,15.3) 25.44,15.63 R621.1 ; v1(17.08,20.81) 16.52,21.38 16.52,21.77 16.03,22.26 C535.1 ; U514.1 16.96,12.24 16.73,12 16.73,10.48 16.95,10.26 16.95,9.11 17.49,8.57 17.49,8.46 v1(17.87,8.09)
  BOTTOM w0.406: v1(13.04,13.37) C545.1 ; R605.1 21.73,26.68
  BOTTOM w0.508: C540.1 C539.1 R613.1 32.22,16.85 32.68,16.39 R616.1 34.68,16.39 v1(35.14,16.85) ; v1(13.64,19.96) 13.14,20.46 C536.1 C538.1 ; R607.1 v1(13.5,26.32) ; 21.73,26.68 J20.1
  BOTTOM w0.635: J20.1 23.15,26.55 23.33,26.38 R606.1 C533.1 ; R610.1 v1(33.19,20.46)
P3V3_SW: length 320.1
  TOP w0.508: TPAD50.1 83.25,15.2 C104.1 ; v1(84.8,17.64) C99.1
  TOP w0.635: R93.1 R97.1 48.73,64.4 49.62,63.51 L3.2 49.62,58.51 49.62,58.5 C24.1 C26.1 C30.1 TPAD35.1 50.89,53.36 51.14,53.11 TP26.1 50.19,52.35 R182.2 ; C85.1 34.89,31.84 TP53.1 J3.10 ; v1(113.5,56.83) TS7.1 120.35,56.83 121.18,57.66 L4.1 121.28,58.62 R133.1 122.59,59.9 123.91,61.22 123.91,73.55 123.46,74 v1(122.9,74) R41.1 ; C99.1 84.54,16.47 C104.1 84.54,11.77 83.53,10.75 P1.1 ; R288.2 v1(8.69,21.18)
  L4_PWR_1 w0.635: TP26.1 47.56,51.39 42.18,56.78 42.18,61.68 41.01,62.85 41.01,63.94 40.37,64.58 38.16,64.58 37.2,65.54 37.2,69.13 37.74,69.67 37.74,70.25 37.34,70.66 36.78,70.66 J7.1 ; v1(97.65,65.09) 98.14,64.59 98.5,64.59 101.28,61.81 106.64,61.81 111.62,56.83 v1(113.5,56.83) 113.68,56.65 113.68,54.47 113.31,54.1 113.31,53.92 106.77,47.38 106.77,43.96 106.03,43.23 106.03,17.87 105.56,17.4 85.74,17.4 85.5,17.64 v1(84.8,17.64)
  L5_PWR_2 w0.508: J3.10 36.54,29.17 ; J3.10 35.52,28.15 ; J3.10 35.52,30.19 ; J3.10 34.51,29.17
  L5_PWR_2 w0.635: v1(97.65,65.09) 97.65,64.38 97.23,63.95 96.65,63.95 96.24,64.36 96.24,69.57 91.92,73.89 82.7,73.89 81.25,72.44 73.53,72.44 71.63,74.34 57.99,74.34 57.82,74.51 53.02,74.51 50.74,72.22 45.22,72.22 44.42,73.02 36.93,73.02 J7.1
  L6_INT_2 w0.508: v1(122.9,74) 115.74,81.16 109.56,81.16 108.06,79.66 v1(103.42,79.66)
  L6_INT_2 w0.635: v1(6.01,76.59) 7.66,74.94 12.66,74.94 13.68,73.92 17.44,73.92 17.82,73.54 19.24,73.54 20.64,72.15 30.06,72.15 30.98,73.06 34.38,73.06 J7.1
  BOTTOM w0.508: v1(97.65,65.09) 97.65,64.45 98.41,63.69 R521.2 ; R574.2 L500.2 39.46,39.3 38.98,38.82 38.98,37.98 v1(38.15,37.16) ; R501.2 v1(103.42,79.66)
  BOTTOM w0.635: R504.2 v1(6.01,76.59)
P5V0: length 327.1
  TOP w0.635: v1(14.17,74.85) R12.1 R9.1 ; v1(104.05,41.18) 104.41,40.83 TS12.1 ; J3.13 TP52.1 C79.1 ; C113.1 C112.1 22.57,13.14 TPAD51.1 ; C113.1 P1.49 ; C113.1 23.69,10.75 v1(24.04,11.11) ; R181.2 47.21,53.38 46.9,53.68 v1(46.9,55.59) ; TPAD2.1 v1(122.9,75.78)
  TOP w0.762: R35.1 R6.1 TPAD2.1 ; J18.3 J7.3 37,68.01 37.81,68.01 J8.2 ; D6.A3 D6.A2 ; D6.A2 102.91,38.31 103.01,38.42 TS12.1 ; D6.A2 D6.A1
  L4_PWR_1 w0.635: v1(46.9,55.59) 45.71,55.59 44.95,56.35 44.95,65.11 43.09,66.96 41.29,66.96 J8.2 45.3,69.23 45.42,69.34 54.03,69.34 57.53,65.83 81.51,65.83 83.26,67.59 97.79,67.59 v1(99.38,66) 99.38,72.5 100.95,74.08 121.2,74.08 v1(122.9,75.78) ; J18.3 34.29,68.6 34.29,72.9 33.54,73.65 31.08,73.65 30.11,72.68 20.49,72.68 19.48,73.68 15.34,73.68 v1(14.17,74.85)
  L5_PWR_2 w0.635: v1(104.05,41.18) 104.05,45.53 106.64,48.12 106.64,58.15 102.45,62.34 102.45,62.93 v1(99.38,66) ; v1(24.04,11.11) 25.49,9.66 27.27,9.66 28.77,11.16 30.87,11.16 32.04,9.99 39.74,9.99 41.11,11.36 41.11,12.91 43.32,15.12 46.04,15.12 48.04,17.13 48.04,24.17 47.51,24.7 47.51,26.66 48.22,27.37 48.22,29.53 46.67,31.07 39.97,31.07 J3.13 38.06,32.43 39.98,34.35 45.6,34.35 47.28,36.03 47.28,38.57 49.14,40.42 49.14,45.86 52.79,49.52 52.79,52.08 49.29,55.59 v1(46.9,55.59)
  BOTTOM w0.635: R522.2 99.83,65.54 v1(99.38,66) ; R517.2 20.73,64.51 20.28,64.96 20.28,66.66 21.04,67.42 21.04,72.15 19.37,73.82 15.9,73.82 14.87,74.85 v1(14.17,74.85)
P5V0_SDA_USB_CONN_VBUS: length 8.4
  TOP w0.279: v1(8.12,10.45) 8.41,10.74 L9.1
  TOP w0.406: v1(8.12,10.45) 6.62,10.45 5.2,11.87 J24.1
  BOTTOM w0.279: U515.5 8.93,11.57 9.13,11.36 9.13,10.73 8.85,10.45 v1(8.12,10.45)
P5V0_V1SBC: length 92.4
  TOP w0.279: 27.83,58.25 27.55,58.53 v1(27.55,58.61)
  TOP w0.356: 27.88,51.14 27.57,51.45 U9.6
  TOP w0.406: R140.1 27.83,58.25
  TOP w0.508: R132.1 25.74,61.1 25.77,61.12 25.77,61.16 v1(25.77,61.16) ; v1(30.42,52.27) 30.19,52.04 TS10.1
  TOP w0.635: TPAD7.1 39.03,73.62 39.03,73.06 ; 27.88,51.14 27.88,51.1 28.85,50.12 TS10.1 30.7,49.62 C47.1 C45.1 32.02,52.31 31.85,52.47 31.85,52.8 C31.1
  TOP w0.762: 39.03,73.06 J8.1
  L3_INT_1 w0.508: v1(30.42,52.27) 30.42,54.65 31.66,55.89 31.66,57.6 30.2,59.07 28,59.07 v1(27.55,58.61)
  L5_PWR_2 w0.635: v1(27.55,58.61) 27.55,59.38 v1(25.77,61.16) 24.33,61.16 22.69,62.8 20.77,62.8 16.9,66.66 16.9,69.58 TP5.1 16.29,73.59 19.72,73.59 21.45,71.87 28.82,71.87 29.97,73.02 32.89,73.02 33.67,72.25 33.67,71.99 35.15,70.51 36.6,70.51 36.76,70.66 37.34,70.66 37.49,70.51 37.77,70.51 J8.1
  BOTTOM w0.406: v1(27.55,58.61) 27.32,58.38 R531.1
  BOTTOM w0.635: R526.1 18.45,59.92 17.92,60.45 17.92,65.03 16.57,66.38 16.57,69.91 TP5.1
P5V0_V2SBC: length 30.7
  TOP w0.279: 27.83,49.31 27.64,49.5 U9.3
  TOP w0.406: v1(30.77,46.98) 30.49,47.25 29.98,47.25 29.63,47.61 R204.1 28.49,48.32 28.49,48.65 27.83,49.31
  L5_PWR_2 w0.635: v1(30.77,46.98) 30.87,46.87 30.87,41.92 22.95,34 JP1.1
  BOTTOM w0.508: J15.1 21.65,31.79 21.68,31.76 JP1.1
  BOTTOM w0.635: C528.1 C526.1 31.18,46.57 v1(30.77,46.98)
P5V_SDA: length 13
  TOP w0.279: U24.1 9.58,16.07 9.36,16.29 9.36,16.98 8.93,17.41 v1(7.84,17.41) 7.33,16.9 R293.1
  TOP w0.406: 14.09,17.74 14.82,17.01 C103.1 ; 14.09,17.74 v1(14.09,17.79) ; 14.09,17.74 14.26,17.74 14.57,18.04 C89.1
  TOP w0.508: v1(9.17,12.86) 9.81,12.23 L9.2
  TOP w0.635: C111.1 v1(9.17,12.86)
  BOTTOM w0.279: R628.1 15.51,9.81 15.24,9.54 v1(14.72,9.54) ; R615.1 v1(25.31,17.66) ; v1(14.09,17.79) 14.23,17.65 U510.6
P5V_SDA_PSW: length 85.8
  TOP w0.508: TPAD49.1 12.9,17.51 U24.6
  TOP w0.635: TPAD49.1 12.38,17.51 11.95,17.08 v1(10.4,17.08)
  L5_PWR_2 w0.635: v1(7.05,29.47) 7.05,50.3 7.67,50.92 7.67,55.98 10.15,58.46 16.07,58.46 16.68,57.85 23.58,57.85 25.41,56.02 26.63,56.02 28.89,58.28 28.89,61.37 28.4,61.86 28.4,62.84 30.24,64.68 37.02,64.68 J8.3
  BOTTOM w0.635: v1(10.4,17.08) 7.05,20.43 v1(7.05,29.47)
VBAT: length 56.8
  TOP w0.635: J3.1 C82.1 ; 16.32,65.39 C12.1 ; C12.1 15.81,65.9 ; C12.1 16.83,65.9 ; J3.22 C86.1 ; TP2.1 J18.1
  TOP w0.889: D4.A 17.6,65.57 ; D4.A 18.49,64.32 ; D4.A 16.71,64.32 ; D4.A 17.6,63.08 ; v1(8.22,50.44) R180.2 ; R180.2 9.08,51.32 9.91,52.14 v1(10.25,52.14) R163.1 ; R180.2 v1(6.97,51.32) ; J9.1 10.38,64.88 ; J9.1 12.29,63.97 ; J9.1 8.46,63.97
  TOP w1.016: J3.3 J3.6
  L4_PWR_1 w0.508: J3.3 28.92,24.09 ; J3.3 27.9,25.11 ; J3.3 26.89,24.09 ; J18.1 33.33,71.77 ; J18.1 31.42,71.77 ; J18.1 32.37,72.72 ; J18.1 32.37,70.81 ; 45.68,28.15 J3.22 ; J3.22 45.68,30.19 ; J3.22 44.67,29.17 ; J17.2 4.66,28.15 ; J17.2 3.64,29.17 ; J17.2 2.63,28.15 ; J17.2 3.64,27.14 ; J9.1 12.29,63.97 ; J9.1 10.38,63.05 ; J9.1 10.38,64.88 ; J9.1 8.46,63.97 ; J3.1 27.9,30.19 ; J3.1 26.89,29.17 ; J3.1 28.92,29.17 ; J3.1 27.9,28.15 ; J13.2 4.66,42.25 ; J13.2 3.64,41.23 ; J13.2 2.63,42.25 ; J13.2 3.64,43.27 ; J3.6 31.46,24.09 ; J3.6 30.44,25.11 ; J3.6 29.43,24.09
  vias: v1(19.01,66.23) v1(19.01,65.54)
VCC_HYPRFLASH: length 23.9
  L6_INT_2 w0.191: v1(32.83,43.04) 33.94,41.93 34.28,41.59 v1(34.79,41.59)
  BOTTOM w0.279: R574.1 R575.1
  BOTTOM w0.406: R575.1 37.13,41.98 TPAD504.1 35.93,42 35.52,41.59 v1(34.79,41.59) ; L500.1 R574.1 ; U508.8 C532.1 C531.1 C529.1 25.12,42 26.37,40.75 29.12,40.75 31.41,43.04 v1(32.83,43.04)
VCCA_LS_SBC: length 89.2
  TOP w0.508: v1(36.23,56.29) 35.98,56.04 35.31,56.04 34.89,55.62 R153.1
  L3_INT_1 w0.635: v1(23.28,63.97) 21.24,63.97 v1(19.9,62.63) 19.2,62.63 19.11,62.53 18.07,62.53 13.7,58.16 v1(13.7,57.47) ; v1(35.24,52.84) 30.81,48.41 30.8,48.41 v1(30.31,47.92)
  L6_INT_2 w0.635: v1(35.24,52.84) 32.57,52.84 29.56,55.85 29.52,55.85 29.11,56.26 29.11,57.6 v1(29.93,58.43) ; v1(30.31,47.92) 29.81,47.42 23.76,47.42 23.13,48.06 23.13,50.91 23.66,51.45 v1(23.66,52.66) 21.81,54.52 15.79,54.52 13.7,56.6 v1(13.7,57.47)
  BOTTOM w0.203: U506.1 35.07,52.13 35.24,52.31 v1(35.24,52.84) ; v1(36.23,56.29) 36.23,56.91 35.37,57.77 U503.1 ; U502.1 14.47,58.86 13.7,58.1 v1(13.7,57.47) ; U504.1 22.14,54.87 22.29,54.72 22.87,54.72 ; U501.1 29.83,59.65 30.1,59.39 30.1,59.08 29.93,58.91 v1(29.93,58.43) ; U500.1 v1(23.28,63.97) ; U507.1 27.71,49.07 28.87,47.92 v1(30.31,47.92)
  BOTTOM w0.406: v1(35.24,52.84) 35.24,53.43 35.22,53.45 35.22,54.09 36.23,55.1 v1(36.23,56.29)
  BOTTOM w0.508: R550.2 26.1,51.55 26.61,52.06 TP505.1 ; 22.87,54.72 22.97,54.62 C520.1 ; 26.61,53.88 C521.1 TP505.1 ; TP505.1 24.35,52.72 24.3,52.66 v1(23.66,52.66) ; R525.2 22.06,59.97 20.51,61.52 20.51,62.02 v1(19.9,62.63)
  BOTTOM w0.635: C519.1 26.61,53.88 ; v1(23.66,52.66) 23.66,53.27 C522.1 C520.1
VCCA_VTRANSL: length 117.6
  TOP w0.279: C83.1 62.57,32.8 62.58,32.81 U22.14 ; U14.14 37.39,39.32 37.38,39.33 C68.1 ; U13.14 46.77,43.19 47.03,42.94 v1(47.56,42.94) ; U16.14 51.03,33.96 50.89,33.82 C80.1 ; C46.1 35.32,49.41 35.51,49.22 35.51,49.2 v1(35.88,48.83) 36.6,48.83 36.84,49.07 U11.14
  TOP w0.406: v1(47.56,42.94) 47.89,43.27 C61.1
  TOP w0.508: C68.1 35.45,39.33 v1(35.14,39.63) ; C83.1 v1(62.57,30.92) 62.09,30.44 60.41,30.44 59.66,29.69 59.66,28.67 58.89,27.9 49.43,27.9 49.06,28.27 49.06,30.74 47.38,32.42 v1(47.38,34.38) 48.65,33.11 C80.1
  TOP w0.635: R242.2 L7.2 48.6,41.49 TPAD40.1 C61.1 C59.1 ; TS8.1 40.65,52.54 39.76,53.43 R176.1 v1(39.2,54.7)
  L3_INT_1 w0.508: v1(62.57,30.92) 63.28,31.63 v1(63.28,33.54) ; v1(35.14,39.63) 35.14,40.46 37.45,42.78 37.45,43.73 36.93,44.26 36.9,44.26 35.57,45.59 35.57,47.58 35.88,47.89 v1(35.88,48.83)
  BOTTOM w0.406: v1(47.38,34.38) 47.74,34.02 49.49,34.02 50.46,34.99 50.46,38.82 48.65,40.63 C530.1 48.65,42.66 48.37,42.94 v1(47.56,42.94) 47.56,43.52 47.31,43.77 C527.1
  BOTTOM w0.508: R548.1 R547.1 R546.1 38.19,54.24 38.65,54.7 v1(39.2,54.7) 39.2,53.81 39.56,53.45 39.56,51.17 37.22,48.83 v1(35.88,48.83) 35.88,45.58 R572.1 R571.1 R570.1 40.75,43.14 42.66,41.23 R573.1 42.66,40.4 43.19,39.86 R579.1 R578.1 R577.1 R576.1 47.08,39.43 R582.1 R584.1 R588.1 R593.1 47.08,34.68 v1(47.38,34.38)
  BOTTOM w0.635: v1(63.28,33.54) R603.1 R597.1 R594.1 R589.1
VCCB_VTRANSL: length 130
  TOP w0.279: U16.1 52.53,33.93 52.41,33.82 C81.1 ; U22.1 64.08,32.81 64.1,32.8 C84.1 ; C75.1 37.38,37.81 37.39,37.82 U14.1 ; C55.1 35.85,47.99 36.54,47.31 v1(36.84,47.31) U11.1 ; R214.1 v1(42.3,44.28) ; U13.1 47.47,45.29 47.79,45.6 47.79,45.98 48.12,46.31 C56.1
  TOP w0.406: v1(35.27,38.19) 35.65,37.81 C75.1 ; v1(48.98,48.91) 48.98,49.49 48.58,49.9 R182.1 R181.1 46.15,50.75 45.81,51.09 C41.1 C32.1
  TOP w0.508: R273.1 68.54,32.75 66.46,30.66 64.46,30.66 64.1,31.02 C84.1
  TOP w0.635: v1(48.98,48.91) C53.1 C56.1 ; C32.1 v1(44.34,51.14) ; TS14.1 70.28,34.02 v1(70,33.74) R273.1 R263.1 R258.1 R252.1 ; C81.1 53.1,33.11 53.61,33.61 TPAD45.1 55.07,32.87 v1(55.07,32.87)
  L3_INT_1 w0.508: v1(43.24,32.56) 42.6,31.92 38.22,31.92 34.82,35.32 34.82,37.74 v1(35.27,38.19) 37.02,39.94 37.02,41.45 38.09,42.51 38.09,44 37.19,44.89 37.16,44.89 36.21,45.85 36.21,46.67 v1(36.84,47.31) ; v1(44.34,51.14) 44.31,51.14 43.75,50.58 43.75,49.01 44.01,48.75 44.01,45.98 v1(42.3,44.28)
  L6_INT_2 w0.508: v1(43.24,32.56) 46.36,32.56 46.44,32.47 50.63,32.47 51.03,32.87 v1(55.07,32.87)
  BOTTOM w0.406: R559.1 43.37,50.66 R553.2 43.88,50.71 44.31,51.14 v1(44.34,51.14) ; v1(43.24,32.56) R599.1
  BOTTOM w0.508: v1(55.07,32.87) 56.28,31.66 60.77,31.66 61.18,32.07 66.23,32.07 67.91,33.74 v1(70,33.74) ; v1(36.84,47.31) 37.34,47.8 38.48,47.8 38.98,47.31 R566.1 40.2,47.03 42.3,44.92 v1(42.3,44.28) R568.1 R569.1
  BOTTOM w0.635: R598.1 54.25,32.87 v1(55.07,32.87) 55.56,33.36 55.95,33.36 56.6,34.02 R596.1 R592.1 R587.1 ; R602.1 R601.1 R600.1 41.26,33.36 42.1,33.36 42.15,33.31 R599.1 ; R560.1 R559.1 R558.1 R557.1
VDD: length 189.6
  TOP w0.635: TPAD12.1 59.78,70.06 R59.1 ; J19.2 57.84,71.3 R59.1 ; R59.1 R60.1 ; R299.2 v1(38.28,13.99) 39.03,13.24 41.03,13.24 41.59,13.8 TS15.1
  L4_PWR_1 w0.635: v1(13.22,75.55) 13.11,75.66 13.11,76.94 13.74,77.58 16.57,77.58 18.67,75.49 26.52,75.49 28.13,73.87 29.83,73.87 30.62,74.66 35.98,74.66 37.3,73.34 46.55,73.34 47.84,72.04 51.47,72.04 52.35,71.17 56,71.17 J19.2
  L5_PWR_2 w0.635: v1(13.22,75.55) 9.74,75.55 6.85,72.65 6.85,61.81 4.74,59.7 2.93,59.7 2.3,59.07 2.3,22.18 4.99,19.49 9.89,19.49 11.11,20.71 14.57,20.71 16.24,19.04 20.64,19.04 21.25,19.64 29.5,19.64 35.15,13.99 v1(38.28,13.99) ; J7.2 36.96,67.94 45.75,67.94 46.03,67.66 46.61,67.66 46.89,67.94 54.48,67.94 J19.2
  BOTTOM w0.635: R505.2 TPAD502.1 12.84,75.17 13.14,75.47 13.22,75.47 v1(13.22,75.55)
VDD_MCU: length 71.4
  TOP w0.203: U8.77 v1(54.18,48.43) ; v1(60.29,68.04) 60.29,67.79 60.29,67.78 60.29,67.4 60.29,67.4 U8.39 ; 77.8,40.98 v1(77.8,39.32) ; v1(59.92,55.43) 59.2,55.43 59.2,55.44 58.81,55.44 58.81,55.43 U7.51 ; 83.93,52.03 83.72,52.03 83.22,52.52 82.48,52.52 82.44,52.48 ; v1(72.29,62.77) 72.28,62.78 72.28,63 72.28,63.01 72.28,63.41 72.29,63.42 U7.11 ; v1(59.93,47.43) 59.2,47.43 59.2,47.42 58.82,47.42 58.81,47.43 U7.67 ; 68.29,40.98 v1(68.29,39.32) ; U8.59 v1(54.18,57.43)
  TOP w0.254: 82.44,52.48 82.22,52.48 82.2,52.43 U8.152 ; U7.124 77.64,52.43 v1(77.11,52.96) ; U7.32 v1(61.79,63.24) ; U8.18 v1(70.79,67.57) ; U7.91 v1(68.79,44.12) ; U8.172 v1(82.44,62.44)
  TOP w0.279: U7.124 81.24,52.43 U8.152
  TOP w0.508: C23.1 53.98,57.24 v1(54.18,57.43) ; v1(68.29,39.32) 68.54,39.07 C73.1 ; C72.1 77.8,38.45 v1(77.8,39.32) ; C50.1 53.97,48.22 v1(54.18,48.43) ; v1(60.29,68.04) 60.29,68.94 C9.1 ; C44.1 83.93,52.03
  TOP w0.635: L1.1 82.07,69.3 82.19,69.43 D2.1 ; TPAD44.1 77.89,38.26 C72.1 ; D2.1 83.27,68.29 82.87,67.88 v1(81.29,67.88) ; D2.1 84.35,69.43 84.94,70.01 84.94,70.95 85.57,71.59 TS4.1 ; J19.1 58.06,72.86 58.1,72.9 R59.2 ; TPAD32.1 C23.1
  L5_PWR_2 w0.508: 55.9,72.86 J19.1 ; J19.1 57.81,72.86 ; J19.1 56.86,73.81 ; J19.1 56.86,71.9
  BOTTOM w0.203: v1(82.44,62.44) 82.92,62.44 82.94,62.46 83.11,62.46 83.27,62.62 C503.1 ; v1(61.79,63.24) 61.79,62.76 61.81,62.74 61.81,62.57 61.81,62.57 C505.1 ; 71.03,68.77 70.79,68.53 v1(70.79,67.57) ; v1(72.29,62.77) 72.78,62.28 73.02,62.28 73.49,61.81 C510.1
  BOTTOM w0.508: C510.1 74.76,61.81 C504.1 ; v1(59.92,55.43) 59.98,55.43 60.08,55.33 C518.1 ; v1(68.79,44.12) 68.66,44.26 68.66,44.86 68.8,45 C525.1 ; 71.03,68.77 71.03,69.28 C502.1 ; C524.1 76.9,52.74 v1(77.11,52.96)
  BOTTOM w0.635: C516.1 60.67,56.25 60.79,56.12 C518.1 ; v1(81.29,67.88) 81.29,68.72 80.71,69.3 R509.2
VDD_MCU_ENETSW: length 35.4
  TOP w0.203: L6.2 99.19,53.55 99.44,53.81 U3.1 ; U12.1 99.31,45.93 99.19,46.06 R207.1 ; U10.1 93.69,51.17 93.18,51.67 R178.1
  TOP w0.508: R156.1 v1(105.74,53.81) ; v1(93.97,46.11) 92.62,47.46 R200.1 ; R217.1 v1(105.37,44.52) ; v1(97.57,49.44) 97.68,49.54 97.89,49.54 98.22,49.87 R190.1 ; R188.1 v1(104.66,50.38) ; R207.1 97.57,46.06 v1(97.19,46.44)
  TOP w0.635: R179.2 L6.2 98.64,54.7 C28.1 C27.1 95.72,54.95 TPAD36.1 93.81,54.19 v1(93.18,53.55) R178.1
  BOTTOM w0.203: v1(98.13,51.19) 98.13,52.11 98.39,52.36 U505.1
  BOTTOM w0.508: v1(94.17,55.29) 94.68,54.78 95.4,54.78 95.57,54.95 C27.1 95.92,54.14 R545.1 ; R539.1 103.56,56.27 v1(104.72,55.11)
VDD_MCU_PERH: length 157.2
  TOP w0.406: R121.1 R113.1 ; TPAD17.1 85.26,67.52 85.38,67.65 87.46,67.65
  TOP w0.508: J6.14 82.51,78.7 82.51,76.03 C2.1 84.04,73.95 84.59,73.39 v1(84.59,72.98) ; R72.1 96.94,69.94 v1(97.07,70.06) TP6.1 ; v1(95.03,52.94) 95.64,53.55 L6.1 ; R60.2 v1(63.12,72.9) ; v1(83.67,62) 84.16,61.5 R113.1 ; R107.1 R95.1 R90.1 v1(97.27,66.89) ; J5.10 C88.1 ; v1(49.81,38.64) 49.77,38.64 49.77,38.64 49.62,38.8 R242.1 ; v1(21.58,73.77) 21.04,74.31 R36.1 ; R37.1 v1(24.09,73.89) ; R161.2 v1(114.01,53.81)
  TOP w0.635: TS16.1 89.8,12.38 v1(90.59,11.59) 90.59,9.81 SW3.1 SW3.3 ; TPAD17.1 84.54,68.35 85.7,69.51 85.7,70.13 v1(86.19,70.62) ; v1(97.16,11.38) SW4.1 SW4.3 ; L7.1 R242.1 ; J3.4 30.54,29.27 C87.1 ; C88.1 83.78,23.51 v1(83.32,23.05) ; R179.1 L6.1
  L3_INT_1 w0.762: v1(43.71,64.74) 43.14,64.74 43.08,64.81 42.45,64.81 42.04,64.4 32.47,64.4 28.59,68.29 28.59,69.45 24.69,73.35 24.63,73.35 v1(24.09,73.89)
  L4_PWR_1 w0.508: 83.78,25.6 J5.10 ; J5.10 84.81,26.63 ; J5.10 83.78,27.66 ; J5.10 82.75,26.63 ; v1(24.09,73.89) 23.64,74.34 23.33,74.34 23.3,74.36 22.16,74.36 v1(21.58,73.77)
  L5_PWR_2 w0.762: v1(43.71,64.74) 40.58,64.74 34.38,58.54 34.38,55.73 32.18,53.53 26.32,53.53 22.06,49.27 v1(22.06,48.25) 22.06,47.48 23.23,46.31 23.23,39.94 19.77,36.48 19.77,33.67 21.42,32.01 21.42,30.57 22.03,29.96 24.73,29.96 25.46,30.69 28.92,30.69 J3.4
  BOTTOM w0.508: R550.1 23.94,51.55 22.06,49.67 v1(22.06,48.25) ; v1(97.14,59.75) 96.15,60.74 R518.1
VDDA_MCU: length 33.5
  TOP w0.16: v1(69.78,67.63) 69.79,67.63 U8.20 ; U7.13 v1(71.29,62.62)
  TOP w0.203: v1(69.78,67.63) 69.78,68.11 69.79,68.12 69.79,68.43 69.78,68.44 69.78,68.7
  TOP w0.508: L1.2 79.26,69.3 v1(78.36,70.2) 77.7,70.2 TPAD14.1 76.03,69.3 75.91,69.43 D1.1 C5.1 72.86,69.3 C7.1 C6.1 69.78,68.76 69.78,68.7
  TOP w0.635: L1.2 80.1,70.71 79.44,71.37 TS3.1
  BOTTOM w0.191: 71.29,63.81 71.29,63.45 71.3,63.43 71.3,63.11 71.29,63.1 v1(71.29,62.62)
  BOTTOM w0.203: v1(69.78,67.63) 69.78,68.11 69.79,68.12 69.79,68.43 69.78,68.44 69.78,68.51 70.07,68.79
  BOTTOM w0.381: 70,66.67 69.78,66.9 v1(69.78,67.63)
  BOTTOM w0.508: 71.29,63.81 71.29,65.38 70,66.67 ; 70.07,68.79 70.07,69.14 70.09,69.16 R508.2 ; R509.1 v1(78.36,70.2) ; v1(71.29,62.62) 70.83,62.16 C506.1
  BOTTOM w0.635: C509.1 C508.1 C507.1 C506.1 C511.1
ADC_POT: length 68.3
  TOP w0.406: v1(110.48,49.36) C48.1 R194.2 TP27.1
  L3_INT_1 w0.191: v1(110.48,49.36) 106.57,45.46 96.38,45.46 94.68,47.16 94.46,47.16 93.99,47.62 v1(93.99,52.03)
  L6_INT_2 w0.191: 83.93,39.49 84.08,39.49 84.09,39.48 85.24,39.48 89.52,43.77 89.52,47.31 90.82,48.6 90.82,50.48 92.37,52.03 v1(93.99,52.03) ; 82.28,38.62 81.93,38.26 75.93,38.26 73.98,36.31 70.85,36.31 69.05,38.11 v1(65.26,38.11)
  L6_INT_2 w0.203: 83.93,39.49 83.21,39.49 83.2,39.48 83.15,39.48 82.28,38.62
  BOTTOM w0.406: R583.1 64.45,38.34 64.68,38.11 v1(65.26,38.11)
CAN_H: length 18.8
  TOP w0.254: 13.65,59.07 13.65,61.17 14.34,61.86 TP11.1 ; J11.1 4.6,57.43 6.64,57.43 6.93,57.72 C20.1 7.87,57.72 8.17,57.43 8.82,57.43 8.89,57.5 9.46,57.5 9.77,57.56 9.97,57.86 R125.1 11.65,58.38 12.08,57.94 12.57,57.94 12.9,58.27 12.9,58.31 12.94,58.35
  TOP w0.279: 13.65,59.07 12.94,58.35
  TOP w0.406: R112.2 TP11.1
CAN_L: length 14.4
  TOP w0.254: 13.25,58.05 13.2,58 13.17,58 12.72,57.56 12.55,57.56 12.31,57.31 12.31,57.26 12.28,57.24 R138.2 TP20.1 10.15,56.99 9.85,57.19 9.49,57.12 9.05,57.12 8.98,57.05 8.17,57.05 7.87,56.75 C25.1 6.93,56.75 6.64,57.05 4.85,57.05 J11.2
  TOP w0.279: R135.2 14.03,58.84 13.25,58.05
CANH_OUT: length 74.6
  TOP w0.254: R119.2 15.91,60.84 15.44,60.37 15.29,60.37 14.82,60.84 v1(14.47,60.84)
  L6_INT_2 w0.191: v1(29.56,21.68) 29.56,22.08 29.01,22.64 29.01,29.95 27.81,31.15 27.81,32.49 17.45,42.86 17.45,49 16.8,49.65 16.37,49.65 11.4,54.62 11.4,54.88 11.4,59.76 12.32,60.67 13.69,60.67 13.99,60.58 v1(14.47,60.84)
  BOTTOM w0.254: J3.21 44.22,23.01 44.22,22.53 43.68,21.98 41.9,21.98 41.52,22.36 34.28,22.36 33.82,21.91 30.92,21.91 29.76,20.74 28.28,20.74 27.65,21.37 27.65,22.18 27.98,22.51 29.12,22.51 29.56,22.08 v1(29.56,21.68)
CANL_OUT: length 75.6
  TOP w0.254: v1(14.16,59.8) 14.65,60.29 14.83,60.29 15.28,59.85 R134.2
  L6_INT_2 w0.191: v1(14.16,59.8) 13.9,60.28 13.64,60.35 12.45,60.35 11.72,59.62 11.72,54.75 16.5,49.97 16.93,49.97 17.77,49.13 17.77,42.99 28.13,32.62 28.13,31.28 29.32,30.08 29.32,22.77 29.78,22.31 v1(30.19,22.31)
  BOTTOM w0.254: v1(30.19,22.31) 29.87,22.31 29.28,22.9 27.82,22.9 27.27,22.34 27.27,21.21 28.12,20.36 29.91,20.36 31.08,21.52 33.98,21.52 34.44,21.98 41.36,21.98 41.74,21.6 43.83,21.6 44.6,22.37 44.6,23.01 J3.24
ENET_MII_TXC: length 8.9
  TOP w0.279: R96.1 v1(106.64,65.36) 107.68,65.36 108.87,66.55 J16.20
  BOTTOM w0.203: v1(106.64,65.36) R96.1 R513.1
ENETSW_INH: length 104.5
  TOP w0.406: R2.2 v1(102.45,78.7)
  L3_INT_1 w0.191: v1(102.45,78.7) 103.52,78.7 104.1,78.12 104.1,70.22 103.91,70.03 102.99,70.03 101.85,68.9 101.85,66.99 101.21,66.35 101.21,60.37 98.69,57.85 98.69,54.31 98.78,54.22 100.09,54.22 100.18,54.31 100.18,56.05 100.28,56.14 100.41,56.14 100.5,56.05 100.5,54.31 100.59,54.22 100.72,54.22 100.82,54.31 100.82,56.05 100.91,56.14 101.04,56.14 101.13,56.05 101.13,54.31 101.23,54.22 101.36,54.22 101.45,54.31 101.45,56.05 101.55,56.14 101.68,56.14 101.77,56.05 101.77,54.31 101.86,54.22 101.99,54.22 102.09,54.31 102.09,56.05 102.18,56.14 102.31,56.14 102.4,56.05 102.4,54.31 102.5,54.22 102.82,54.22 102.91,54.12 102.91,53.99 102.82,53.9 98.78,53.9 98.69,53.81 98.69,53.67 98.78,53.58 102.82,53.58 102.91,53.49 102.91,53.36 102.82,53.26 98.78,53.26 98.69,53.17 98.69,53.04 98.78,52.95 102.82,52.95 102.91,52.85 102.91,52.72 102.82,52.63 98.78,52.63 98.69,52.54 98.69,52.4 98.78,52.31 102.82,52.31 102.91,52.22 102.91,52.09 102.82,51.99 98.78,51.99 98.69,51.9 98.69,51.77 98.78,51.68 102.82,51.68 102.91,51.58 102.91,51.45 102.82,51.36 101.52,51.36 101.43,51.27 101.43,50.71 101.33,50.61 101.2,50.61 101.11,50.71 101.11,51.27 101.02,51.36 100.88,51.36 100.79,51.27 100.79,50.71 100.7,50.61 100.57,50.61 100.47,50.71 100.47,51.27 100.38,51.36 100.25,51.36 100.16,51.27 100.16,50.71 100.06,50.61 99.93,50.61 99.84,50.71 99.84,51.27 99.75,51.36 99.61,51.36 99.52,51.27 99.52,50.71 99.43,50.61 99.3,50.61 99.2,50.71 99.2,51.27 99.11,51.36 98.78,51.36 98.69,51.27 98.69,50.77 98.13,50.21 98.13,49.84 98.23,49.75 99.42,49.75 99.51,49.66 99.51,49.52 99.42,49.43 98.23,49.43 98.13,49.34 v1(98.13,48.37)
  BOTTOM w0.203: U505.7 99.78,50.25 99.76,50.23 R556.2 TPAD503.1 98.13,48.6 v1(98.13,48.37)
ENETSW_RESET: length 105.3
  TOP w0.279: R258.2 v1(66.54,35.77) 66.28,35.52 U22.4
  TOP w0.406: R1.2 v1(104.48,80.46)
  L3_INT_1 w0.191: v1(104.48,80.46) 104.48,79.77 104.58,79.68 107.13,79.68 107.23,79.59 107.23,79.46 107.13,79.36 104.58,79.36 104.48,79.27 104.48,79.14 104.58,79.05 107.13,79.05 107.23,78.95 107.23,78.82 107.13,78.73 104.58,78.73 104.48,78.64 104.48,78.5 104.58,78.41 107.13,78.41 107.23,78.32 107.23,78.19 107.13,78.09 104.58,78.09 104.48,78 104.48,77.87 104.58,77.78 107.13,77.78 107.23,77.68 107.23,77.55 107.13,77.46 104.58,77.46 104.48,77.37 104.48,77.23 104.58,77.14 107.13,77.14 107.23,77.05 107.23,76.92 107.13,76.82 104.58,76.82 104.48,76.73 104.48,76.6 104.58,76.51 107.13,76.51 107.23,76.41 107.23,76.28 107.13,76.19 104.58,76.19 104.48,76.1 104.48,69.63 103.87,69.02 102.83,69.02 102.17,68.36 102.17,65 101.84,64.67 101.84,60.28 v1(99.17,57.62)
  L6_INT_2 w0.191: v1(99.17,57.62) 99.17,56.08 91.45,48.35 91.45,48.34 90.16,47.04 90.16,43.51 85.44,38.78 83.57,38.78 82.41,37.63 76.2,37.63 74.25,35.68 68.87,35.68 68.77,35.77 v1(66.54,35.77)
ENETSW_RESET_A: length 5.2
  TOP w0.229: U22.11 60.72,35.52 60.66,35.58 60.51,35.58 v1(60.16,35.93)
  TOP w0.406: R251.2 R261.2 59.75,35.42 60.16,35.82 v1(60.16,35.93)
  BOTTOM w0.406: R594.2 60.62,35.42 60.16,35.88 v1(60.16,35.93)
ENETSW_SCL: length 104.5
  TOP w0.203: R199.2 94.5,49.24 94.34,49.39 U10.6
  TOP w0.406: v1(96.81,48.75) 96.33,49.24 R199.2 ; v1(102.32,75.7) 102.48,75.85 102.55,75.85 103.21,76.51 TPAD3.1 R7.2
  L3_INT_1 w0.191: v1(96.81,48.75) 97.83,47.74 98.95,47.74 99.13,47.55 99.13,47.48 99.22,47.39 100.15,47.39 100.24,47.29 100.24,47.16 100.15,47.07 99.22,47.07 99.13,46.98 99.13,46.73 99,46.59 97.98,46.59 97.65,46.92 96.08,46.92 95.63,47.37 95.63,47.5 96.16,48.03 96.16,48.16 96.07,48.25 95.94,48.25 95.41,47.72 95.28,47.72 95.18,47.82 95.18,47.95 95.71,48.48 95.71,48.61 95.62,48.7 95.49,48.7 94.96,48.17 94.83,48.17 94.55,48.45 94.55,49.05 94.64,49.14 96.24,49.14 96.33,49.24 96.33,49.37 96.24,49.46 94.64,49.46 94.55,49.55 94.55,49.68 94.64,49.78 96.24,49.78 96.33,49.87 96.33,50 96.24,50.1 94.64,50.1 94.55,50.19 94.55,50.51 94.64,50.6 96.24,50.6 96.33,50.69 96.33,50.82 96.24,50.92 94.64,50.92 94.55,51.01 94.55,51.14 94.64,51.23 96.24,51.23 96.33,51.33 96.33,51.46 96.24,51.55 94.64,51.55 94.55,51.64 94.55,51.78 94.64,51.87 95.42,51.87 95.51,51.96 95.51,52.23 95.6,52.32 95.73,52.32 95.83,52.23 95.83,51.96 95.92,51.87 96.24,51.87 96.56,52.19 96.56,52.55 96.47,52.64 95.6,52.64 95.51,52.73 95.51,52.87 95.6,52.96 96.47,52.96 96.56,53.05 96.56,53.18 96.47,53.28 95.6,53.28 95.51,53.37 95.51,53.5 95.6,53.59 96.47,53.59 96.56,53.69 96.56,54 96.47,54.1 95.91,54.1 95.82,54.19 95.82,54.32 95.91,54.41 96.47,54.41 96.56,54.51 96.56,55.93 96.81,56.18 96.94,56.18 97.37,55.75 97.51,55.75 97.6,55.84 97.6,55.97 97.17,56.41 97.17,56.54 97.88,57.25 97.88,57.58 97.79,57.67 97.13,57.67 97.03,57.76 97.03,57.9 97.13,57.99 97.79,57.99 97.88,58.08 97.88,59.29 98.1,59.52 98.24,59.52 98.78,58.97 98.92,58.97 99.01,59.06 99.01,59.19 98.46,59.74 98.46,59.88 98.55,59.97 98.68,59.97 99.23,59.42 99.37,59.42 99.46,59.51 99.46,59.64 98.91,60.19 98.91,60.32 99,60.42 99.13,60.42 99.68,59.87 99.81,59.87 99.91,59.96 99.91,60.09 99.08,60.92 99.08,64.89 99.86,65.67 99.86,66.78 99.77,66.87 99.17,66.87 99.08,66.96 99.08,67.09 99.17,67.19 100,67.19 100.09,67.28 100.09,67.41 100,67.51 99.17,67.51 99.08,67.6 99.08,67.73 99.17,67.82 100,67.82 100.09,67.92 100.09,68.05 100,68.14 99.17,68.14 99.08,68.23 99.08,68.36 99.17,68.46 100,68.46 100.09,68.55 100.09,68.68 100,68.78 99.17,68.78 99.08,68.87 99.08,69 99.17,69.09 100,69.09 100.09,69.19 100.09,69.32 100,69.41 99.17,69.41 99.08,69.5 99.08,69.63 99.17,69.73 100,69.73 100.09,69.82 100.09,69.95 100,70.05 99.17,70.05 99.08,70.14 99.08,70.27 99.17,70.36 100,70.36 100.09,70.46 100.09,70.59 100,70.68 99.17,70.68 99.08,70.77 99.08,70.9 99.17,71 100,71 100.09,71.09 100.09,71.22 100,71.32 99.17,71.32 99.08,71.41 99.08,71.54 99.17,71.63 100,71.63 100.09,71.73 100.09,71.86 100,71.95 99.17,71.95 99.08,72.04 99.08,72.17 99.17,72.27 100,72.27 100.09,72.36 100.09,72.49 100,72.59 99.17,72.59 99.08,72.68 99.08,72.81 99.17,72.9 100,72.9 100.09,73 100.09,73.47 100.66,74.04 100.66,74.17 99.75,75.08 99.75,75.21 99.84,75.3 99.97,75.3 100.88,74.39 101.01,74.39 101.11,74.49 101.11,74.62 100.2,75.53 100.2,75.66 100.29,75.75 100.42,75.75 101.33,74.84 101.46,74.84 101.56,74.94 101.56,75.07 100.65,75.98 100.65,76.11 100.74,76.2 100.87,76.2 101.78,75.29 101.91,75.29 v1(102.32,75.7)
ENETSW_SDA: length 104.2
  TOP w0.203: U10.7 95.34,50.12 R185.2
  TOP w0.406: v1(102.35,74.99) 102.81,74.99 TPAD5.1 103.47,75.65 R8.2 ; R185.2 96.43,50.51 96.84,50.1 v1(96.84,49.67)
  L3_INT_1 w0.191: v1(96.84,49.67) 96.84,50.57 97.17,50.9 97.17,51.03 96.88,51.32 96.88,51.45 96.97,51.54 97.1,51.54 97.39,51.25 97.52,51.25 97.62,51.35 97.62,51.48 97.33,51.77 97.33,51.9 97.42,51.99 97.55,51.99 97.84,51.7 97.97,51.7 98.2,51.93 98.2,52.35 98.1,52.44 97.03,52.44 96.94,52.53 96.94,52.66 97.03,52.76 98.1,52.76 98.2,52.85 98.2,52.98 98.1,53.08 97.03,53.08 96.94,53.17 96.94,53.3 97.03,53.39 98.1,53.39 98.2,53.49 98.2,53.62 98.1,53.71 97.03,53.71 96.94,53.8 96.94,53.93 97.03,54.03 98.1,54.03 98.2,54.12 98.2,54.25 98.1,54.35 97.03,54.35 96.94,54.44 96.94,54.57 97.03,54.66 98.1,54.66 98.2,54.76 98.2,54.89 98.1,54.98 97.03,54.98 96.94,55.07 96.94,55.2 97.03,55.3 98.3,55.3 98.37,55.37 98.37,55.98 98.28,56.07 98.01,56.07 97.92,56.17 97.92,56.3 98.01,56.39 98.28,56.39 98.37,56.48 98.37,57.98 100.9,60.5 100.9,60.83 100.8,60.93 99.71,60.93 99.62,61.02 99.62,61.15 99.71,61.24 100.8,61.24 100.9,61.34 100.9,61.47 100.8,61.56 99.71,61.56 99.62,61.65 99.62,61.79 99.71,61.88 100.8,61.88 100.9,61.97 100.9,62.1 100.8,62.2 99.71,62.2 99.62,62.29 99.62,62.42 99.71,62.51 100.8,62.51 100.9,62.61 100.9,62.74 100.8,62.83 99.71,62.83 99.62,62.92 99.62,63.06 99.71,63.15 100.8,63.15 100.9,63.24 100.9,63.37 100.8,63.47 99.71,63.47 99.62,63.56 99.62,63.69 99.71,63.78 100.8,63.78 100.9,63.88 100.9,64.01 100.8,64.1 99.71,64.1 99.62,64.19 99.62,64.33 99.71,64.42 100.8,64.42 100.9,64.51 100.9,64.83 100.8,64.92 100.27,64.92 100.18,65.02 100.18,65.15 100.27,65.24 100.8,65.24 100.9,65.33 100.9,65.46 100.8,65.56 100.27,65.56 100.18,65.65 100.18,65.78 100.27,65.88 100.8,65.88 100.9,65.97 100.9,66.48 101.49,67.07 101.49,67.56 101.39,67.65 100.5,67.65 100.41,67.74 100.41,67.87 100.5,67.97 101.39,67.97 101.49,68.06 101.49,68.19 101.39,68.28 100.5,68.28 100.41,68.38 100.41,68.51 100.5,68.6 101.39,68.6 101.49,68.7 101.49,69 103.04,70.55 103.04,70.86 102.94,70.96 102.1,70.96 102.01,70.86 102.01,70.16 101.92,70.06 101.79,70.06 101.69,70.16 101.69,70.86 101.6,70.96 101.47,70.96 101.38,70.86 101.38,70.16 101.28,70.06 101.15,70.06 101.06,70.16 101.06,70.86 100.97,70.96 100.5,70.96 100.41,71.05 100.41,71.18 100.5,71.27 102.94,71.27 103.04,71.37 103.04,71.5 102.94,71.59 100.5,71.59 100.41,71.68 100.41,71.82 100.5,71.91 102.94,71.91 103.04,72 103.04,72.13 102.94,72.23 100.5,72.23 100.41,72.32 100.41,72.45 100.5,72.54 101.12,72.54 101.21,72.64 101.21,73.93 101.3,74.03 101.43,74.03 101.53,73.93 101.53,72.64 101.62,72.54 101.94,72.54 102.13,72.73 102.13,73.33 102.51,73.72 103.67,73.72 103.78,73.84 103.78,74.15 103.69,74.25 103.22,74.25 103.12,74.34 103.12,74.47 103.22,74.56 103.69,74.56 103.78,74.66 103.78,74.79 103.69,74.88 103.22,74.88 103.12,74.97 103.12,75.11 103.22,75.2 103.69,75.2 103.78,75.29 103.78,75.42 103.69,75.52 103.22,75.52 103.12,75.61 103.12,75.74 103.22,75.83 103.69,75.83 103.78,75.93 103.78,76.06 103.69,76.15 103.22,76.15 103.12,76.24 103.12,76.38 103.22,76.47 103.69,76.47 103.78,76.56 103.78,76.69 103.69,76.79 103.22,76.79 103.12,76.88 103.12,77.01 103.22,77.1 103.69,77.1 103.78,77.2 103.78,77.98 103.39,78.38 103.12,78.38 102.81,78.06 102.81,77.6 102.71,77.5 101.91,77.5 101.82,77.41 101.82,77.28 101.91,77.19 102.71,77.19 102.81,77.09 102.81,75.45 v1(102.35,74.99)
ENETSW_SPI_MISO: length 37.8
  TOP w0.191: v1(102.2,47.09) 101.98,47.31 101.47,47.31 101.33,47.16 U12.6
  TOP w0.229: R75.1 TPAD13.1
  TOP w0.406: TPAD13.1 v1(122.44,69.56) ; R202.2 v1(102.2,47.09)
  L3_INT_1 w0.191: v1(122.44,69.56) 122.44,63.44 106.09,47.09 v1(102.2,47.09)
ENETSW_SPI_MOSI: length 28.6
  TOP w0.203: R142.2 101.18,55.71 U3.7
  TOP w0.406: R108.1 v1(121.15,63.71) ; v1(99.91,56.65) TPAD33.1 R142.2
  L3_INT_1 w0.191: v1(99.91,56.65) 111.67,56.65 112.71,57.69 115.13,57.69 v1(121.15,63.71)
ENETSW_SPI_SC: length 33.3
  TOP w0.203: U12.7 100.93,47.2 100.8,47.33 R201.2
  TOP w0.406: R201.2 TPAD37.1 v1(104.61,49.36) ; R94.1 v1(121.15,65.75)
  L3_INT_1 w0.191: v1(104.61,49.36) 107.92,49.36 121.94,63.38 121.94,64.95 v1(121.15,65.75)
ENETSW_SPI_SCK: length 26.5
  TOP w0.203: R144.2 102.83,54.93 102.36,54.46 U3.6
  TOP w0.406: R98.1 v1(121.15,64.73) ; v1(105.45,55.84) TPAD34.1 R144.2
  L3_INT_1 w0.191: v1(121.15,64.73) 121.62,64.25 121.62,63.52 113.94,55.84 v1(105.45,55.84)
EXP: length 47.1
  L3_INT_1 w0.191: v1(39.84,38.57) 38.46,39.94 38.46,42.22 38.56,42.32 38.56,44.57 37.59,45.54 37.59,47.75 v1(38.57,48.73)
  L6_INT_2 w0.191: v1(63.33,35.52) 60.46,38.4 53.77,38.4 v1(51.78,36.41) 51.3,36.88 44.33,36.88 43.4,35.96 42.26,35.96 40.7,37.51 40.7,37.7 v1(39.84,38.57)
  BOTTOM w0.406: v1(45.05,44.54) 43.47,46.11 43.12,46.11 41.19,48.04 40.04,48.04 39.36,48.73 v1(38.57,48.73)
HYPFLASH/QSPI_A_CS: length 4
  BOTTOM w0.279: R575.2 35.53,40.05 35.78,39.81 R581.2
  BOTTOM w0.406: U508.1 R581.2
HYPFLASH/QSPI_A_IO0: length 2.1
  BOTTOM w0.406: U508.5 R595.2
HYPFLASH/QSPI_A_IO1: length 2
  BOTTOM w0.406: U508.2 R585.2
HYPFLASH/QSPI_A_IO2: length 2
  BOTTOM w0.406: U508.3 R590.2
HYPFLASH/QSPI_A_IO3: length 2.1
  BOTTOM w0.406: U508.7 R586.2
HYPFLASH/QSPI_A_SCK: length 2.1
  BOTTOM w0.406: U508.6 R591.2
LED_BLUE: length 26.9
  TOP w0.406: R222.2 86.32,43.04 v1(86.91,43.62)
  L3_INT_1 w0.191: v1(86.91,43.62) 86.91,47.99 87.04,48.12 87.04,51.49 83.99,54.54
  L3_INT_1 w0.203: v1(83.31,55.72) 83.99,55.04 83.99,54.54
  L6_INT_2 w0.203: v1(83.31,55.72) 82.15,55.72 78.45,59.42 75.96,59.42 v1(74.28,57.74)
  BOTTOM w0.203: R529.2 v1(74.28,57.74)
LED_GREEN: length 31.2
  TOP w0.406: v1(84.82,37.53) 84.82,38.34 R245.2
  L3_INT_1 w0.191: 83.93,51.84 84.25,51.53 84.25,43.49 84.82,42.91 v1(84.82,37.53)
  L3_INT_1 w0.203: v1(77.74,58.94) 79.84,56.83 79.84,56.63 80.61,55.87 80.61,54.62 82.51,52.72 83.06,52.72 83.93,51.84
  L6_INT_2 w0.203: v1(77.74,58.94) 75.53,56.73 v1(74.28,56.73)
  BOTTOM w0.203: R533.2 v1(74.28,56.73)
LED_RED: length 31.3
  TOP w0.406: R255.2 v1(84.37,36.41)
  L3_INT_1 w0.191: 81.28,38.62 79.92,37.26 79.92,34.58 v1(79.51,34.17)
  L3_INT_1 w0.203: v1(74.18,53.68) 77.03,50.84 77.88,50.84 79.69,49.02 79.69,42.33 81.28,40.73 81.28,38.62
  L6_INT_2 w0.191: v1(84.37,36.41) 84.01,36.05 82.41,36.05 81.47,35.11 80.45,35.11 v1(79.51,34.17)
  BOTTOM w0.203: R544.2 v1(74.18,53.68)
LEDRGB_BLUE: length 3.7
  TOP w0.406: 92.67,40.98 R229.1 TP43.1 94.5,40.47 94.56,40.41 D6.C3
LEDRGB_GREEN: length 3.5
  TOP w0.406: 92.67,38.31 R247.1 TP46.1 D6.C2
LEDRGB_RED: length 3.5
  TOP w0.406: 92.67,36.15 R256.1 TP48.1 94.5,36.15 94.56,36.21 D6.C1
LIN1: length 26.7
  TOP w0.406: R225.1 7.65,43.22 6.07,44.79 J13.1 ; R225.1 R226.1 TP29.1 v1(10.76,45.63) ; R225.1 C58.1
  BOTTOM w0.406: v1(10.76,45.63) 11.34,45.63 11.7,45.98 15.79,45.98 18.07,48.27 18.07,52.36 R542.2
LIN1_OUT: length 39.8
  L6_INT_2 w0.191: J3.9 31.88,25.19 31.88,27.08 32.54,27.74 33.11,27.74 34.08,28.71 34.08,30.97 32.78,32.27 32.14,32.27 20,44.41 20,49.46 v1(16.24,53.22)
  BOTTOM w0.406: R543.2 v1(16.24,53.22)
LIN2: length 35.1
  TOP w0.406: J17.1 6.07,30.69 6.32,30.95 R279.1 R276.1 ; R276.1 7.58,32.98 TP51.1 ; R276.1 C77.1 8.9,34.68 8.98,34.76
  TOP w0.508: v1(7.91,34.76) 8.98,34.76
  L3_INT_1 w0.191: v1(7.91,34.76) 7.91,43.6 10.81,46.49 v1(10.81,55.61)
  BOTTOM w0.203: v1(10.81,55.61) 11.16,55.61 R535.2
LIN2_OUT: length 56.6
  L6_INT_2 w0.191: v1(10.6,57.21) 10.6,56.08 10.33,55.81 10.33,55.29 11.09,54.54 11.09,54.48 16.26,49.31 16.27,49.33 16.67,49.33 16.95,49.05 16.95,42.85 26.96,32.85 26.96,31.17 26.8,31.02 26.8,21.9 27.17,21.53 29.04,21.53 29.36,21.21 29.76,21.21 30.08,21.53 35.5,21.53 J3.15
  BOTTOM w0.203: R530.2 v1(10.6,57.21)
LVLRST_EN: length 1.2
  BOTTOM w0.203: U509.5 R610.2
MIC2005_CSLEW: length 1.9
  TOP w0.152: C103.2 U24.5
POWER_EN: length 12.6
  TOP w0.508: R300.1 v1(6.64,15.43)
  L6_INT_2 w0.508: v1(15.18,13.37) 14.03,13.37 11.98,15.43 v1(6.64,15.43)
  BOTTOM w0.279: v1(15.18,13.37) 15.54,13.74 15.86,13.74 16.24,14.12 U510.31
PTA0: length 65.3
  TOP w0.16: U8.140 82.84,46.43 83.15,46.73 v1(83.15,46.85) ; U7.115 v1(78.1,47.93)
  TOP w0.203: 83.93,46.65 83.34,46.65 v1(83.15,46.85)
  TOP w0.406: 83.93,46.65 84.06,46.65 R205.2 ; R302.2 v1(103.64,14.18) 103.64,14.79 95.28,23.16 95.28,26.11 95.26,26.12 95.26,27.13 95.98,27.85 96.99,27.85 97,27.84 97.18,27.84 97.69,28.34 97.69,28.65 97.7,28.66 97.7,29.98 95.26,32.42 90.51,32.42 89.29,33.64 84.72,33.64 83.32,35.04 83.32,35.52 83.65,35.85 v1(83.65,36.64)
  BOTTOM w0.16: v1(83.15,46.85) 82.76,46.46 81.09,46.46 79.63,47.93 v1(78.1,47.93)
  BOTTOM w0.203: 83.93,46.65 83.83,46.65 83.63,46.85 v1(83.15,46.85)
  BOTTOM w0.406: 83.93,46.65 86.08,46.65 87.49,45.24 87.49,41.69 83.65,37.86 v1(83.65,36.64)
PTA0/ACMP0_IN0/ADC0_SE0: length 38.6
  TOP w0.406: v1(85.92,45.98) 85.92,46.19 85.51,46.59 R205.1
  BOTTOM w0.191: J4.15 62.35,25.52 66.44,25.52 67.11,26.19 67.11,27.2 67.97,28.06 68.98,28.06 70.88,29.95 70.88,30.97 74.42,34.5 78.16,34.5 85.33,41.68 85.33,45.4 v1(85.92,45.98)
PTA1: length 69
  TOP w0.16: U8.138 82.44,45.42 82.46,45.41 v1(82.92,45.41) ; U7.113 v1(78.1,46.93)
  TOP w0.203: 83.93,45.41 v1(82.92,45.41)
  TOP w0.406: R206.2 84,45.41 83.93,45.41 ; R274.2 v1(102.96,34.8)
  L6_INT_2 w0.191: v1(86.25,48.69) 85.62,48.69 84.46,47.53 84.46,46.27
  L6_INT_2 w0.203: 84.46,46.27 83.6,45.41 v1(82.92,45.41)
  BOTTOM w0.16: v1(82.92,45.41) 81.13,45.41 79.61,46.93 v1(78.1,46.93)
  BOTTOM w0.406: v1(86.25,48.69) 90.08,44.85 90.08,25.77 91.53,24.32 104.07,24.32 105.55,25.8 105.55,34.86 104.89,35.52 104.27,35.52 103.54,34.8 v1(102.96,34.8)
PTA1/ACMP0_IN1/ADC0_SE1: length 35.2
  TOP w0.406: v1(85.89,45.02) 85.48,45.43 R206.1
  BOTTOM w0.191: J4.18 64.57,25.2 66.58,25.2 67.43,26.06 67.43,27.07 68.1,27.74 69.12,27.74 71.2,29.82 71.2,30.83 74.55,34.19 78.32,34.19 85.89,41.75 v1(85.89,45.02)
PTA2/LPUART0_RX: length 156.5
  TOP w0.16: U7.105 v1(75.79,44.12) ; 76.3,40.98 v1(76.3,39.79)
  TOP w0.406: R40.1 62.45,73.9 62.73,73.61 v1(63.99,73.61)
  L3_INT_1 w0.191: v1(17.54,55.34) 17.54,56.93 16.78,57.69 16.78,59.19 17.54,59.94 18.59,59.94 19.84,61.2 19.84,61.4 21.55,63.1 23.18,63.1 23.82,63.74 23.82,67.15 20.55,70.41 20.55,71.92 18.74,73.73 18.09,73.73 v1(17.02,74.8)
  L6_INT_2 w0.191: 83.93,51.17 83.93,51.67 86.59,54.33 86.59,65.56 81.46,70.7 66.9,70.7 v1(63.99,73.61) 59.87,73.61 58.71,74.77 58.71,76.21 59.48,76.97 59.48,83.04 58.59,83.93 18.55,83.93 17.49,82.87 17.49,76.9 17.77,76.62 17.77,75.55 v1(17.02,74.8)
  L6_INT_2 w0.203: 83.93,51.17 82.81,50.04 82.41,50.04 81.6,49.23 81.6,47.75 78.3,44.45 77.9,44.45 77.71,44.64 76.59,44.64 76.08,44.12 v1(75.79,44.12)
  BOTTOM w0.16: v1(75.79,44.12) 75.79,42.75 76.3,42.24 v1(76.3,39.79)
  BOTTOM w0.406: R536.1 v1(17.54,55.34)
PTA2/LPUART0_RX_LS: length 8.9
  TOP w0.203: 22.69,60.41 v1(22.69,61.18)
  TOP w0.406: TP10.1 22.69,61.68 v1(22.69,61.18)
  L3_INT_1 w0.203: v1(22.69,61.18) 22.69,60.68 22.71,60.66 22.71,57.73 v1(24.24,56.2)
  BOTTOM w0.203: U504.6 23.32,56.32 23.47,56.46 23.98,56.46 v1(24.24,56.2)
PTA3/LPUART0_TX: length 160.2
  TOP w0.16: U7.104 v1(75.29,44.59) ; 75.8,40.98 v1(75.8,39.32)
  TOP w0.406: R39.1 59.56,74.56 59.19,74.93 v1(59.19,75.04)
  L3_INT_1 w0.191: v1(18.4,55.28) 18.4,56.65 17.1,57.95 17.1,59.06 17.67,59.62 18.72,59.62 20.16,61.06 20.16,61.27 21.46,62.57 23.09,62.57 24.14,63.61 24.14,67.28 20.87,70.55 20.87,72.05 18.87,74.04 18.65,74.04 18.1,74.59 18.1,74.9 v1(17.17,75.83)
  L6_INT_2 w0.191: v1(17.17,75.83) 17.17,83 18.42,84.24 58.72,84.24 59.08,83.89 59.8,83.17 59.8,76.84 59.19,76.24 v1(59.19,75.04) 60.13,74.1 64.22,74.1 67.3,71.03 82.17,71.03 86.91,66.29 86.91,53.05 84.72,50.85 84.72,49.49 83.93,48.71
  L6_INT_2 w0.203: v1(75.29,44.59) 75.29,43.94 75.59,43.64 78.47,43.64 82.24,47.41 82.63,47.41 83.58,48.36 83.58,48.39 83.79,48.6 83.82,48.6 83.93,48.71
  BOTTOM w0.16: v1(75.29,44.59) 75.29,42.74 75.8,42.23 v1(75.8,39.32)
  BOTTOM w0.406: R540.1 18.81,54.87 v1(18.4,55.28)
PTA3/LPUART0_TX_LS: length 9.1
  TOP w0.203: R128.1 21.25,60.84 v1(21.25,61.68)
  L3_INT_1 w0.203: v1(23.62,55.91) 23.28,56.25 23.28,56.3 21.25,58.33 v1(21.25,61.68)
  BOTTOM w0.203: U504.7 23.63,55.92 23.63,55.91 v1(23.62,55.91)
PTA4/CMP0_OUT/JTAG_TMS/SWD_DIO: length 180.6
  TOP w0.16: U7.142 v1(76.97,61.43) ; U8.173 v1(82.91,62.94)
  TOP w0.406: v1(27.34,16.65) 27.33,16.63 R294.2
  L3_INT_1 w0.191: 83.93,62.94 93.33,62.94 95.82,65.42 95.82,66.35 95.81,66.35 95.81,70.74 v1(96.15,71.08)
  L3_INT_1 w0.203: 83.93,62.94 v1(82.91,62.94)
  L6_INT_2 w0.191: v1(96.15,71.08) 97.52,71.08 100.46,74.02 103.87,74.02 108.53,69.36 108.53,55.8 108.53,55.03 106.93,53.43 106.93,22.14 106.38,21.58 106.38,21.58 106.19,21.4 97.95,13.16 36.7,13.16 33.22,16.65 v1(27.34,16.65)
  BOTTOM w0.16: v1(76.97,61.43) 78.96,61.43 80.47,62.94 v1(82.91,62.94)
  BOTTOM w0.406: R507.2 95.59,70.52 v1(96.15,71.08)
PTA5/TCLK1_2/RESET: length 226.5
  TOP w0.16: U7.141 v1(78.1,60.93) ; U8.170 v1(82.44,61.44)
  TOP w0.406: R251.1 59.24,37.27 58.63,37.27 v1(58.48,37.12) ; R289.2 v1(36.51,20.85) 37.1,20.85 37.36,20.58 44.11,20.58 J22.1 R295.2 ; D11.C v1(12.13,1.79) ; TS6.1 97.75,63.54 97.47,63.26 v1(96.89,63.26) 96.2,62.57 R110.2 ; R266.1 32.35,35.75 v1(31.94,36.15)
  L3_INT_1 w0.191: v1(36.51,20.85) 36.04,20.85 35.87,21.02 29.55,21.02 29.03,21.54 29.03,29.33 31.94,32.24 v1(31.94,36.15) 31.94,43.79 29.69,46.04 29.69,46.69 28.12,48.26 28.12,54.11 30.52,56.52 30.69,56.52 v1(31.03,56.86) ; 83.93,61.44 95.07,61.44 v1(96.89,63.26)
  L3_INT_1 w0.203: 83.93,61.44 v1(82.44,61.44)
  L6_INT_2 w0.191: J22.1 44.55,20.15 39.99,20.15 39.43,19.59 22.33,19.59 10.99,8.24 10.99,2.93 v1(12.13,1.79) ; v1(35.47,56.68) 35.13,56.34 31.54,56.34 v1(31.03,56.86) ; v1(31.94,36.15) 40.86,36.15 41.84,35.17 46.11,35.17 46.62,35.68 48.64,35.68 48.72,35.6 51.83,35.6 54.31,38.08 54.85,38.08 56.19,36.73 58.1,36.73 v1(58.48,37.12)
  L6_INT_2 w0.203: v1(78.1,60.93) 75.72,60.93 73.75,58.96 73.75,56.58 74.13,56.2 77.15,56.2 78.87,54.48 78.87,46.02 78.26,45.41 77.9,45.41 77.76,45.27 v1(77.18,45.27)
  BOTTOM w0.16: v1(82.44,61.44) 79.6,61.44 79.09,60.93 v1(78.1,60.93)
  BOTTOM w0.191: v1(77.18,45.27) 77.51,44.94 77.51,44.81 79.86,42.47 79.86,39.49 78.22,37.86 66.13,37.86 65.07,36.8 62.92,36.8 62.62,37.09 60.82,37.09 60.43,37.49 60.04,37.49 59.67,37.12 v1(58.48,37.12)
  BOTTOM w0.203: R537.1 v1(35.47,56.68)
PTA6/FTM0_FLT1: length 115.2
  TOP w0.16: 65.29,40.98 v1(65.29,39.32) ; U7.85 v1(65.79,44.12)
  TOP w0.406: R282.1 v1(48.81,23.28)
  L3_INT_1 w0.191: 52.74,67.98 51.72,67.98 45.47,74.23 38.18,74.23 35.44,76.97 35.44,78.87 J2.8 ; v1(73.67,36.79) 71.86,34.97 71.86,25.46 69.34,22.94 49.14,22.94 v1(48.81,23.28)
  L3_INT_1 w0.203: v1(65.79,44.12) 64.6,42.93 58.79,42.93 57.44,44.29 57.44,64.8 55.51,66.73 53.99,66.73 52.74,67.98
  L6_INT_2 w0.191: v1(73.67,36.79) 70.83,36.79 69.18,38.44 66.17,38.44 65.99,38.62
  L6_INT_2 w0.203: v1(65.29,39.32) 65.99,38.62
  BOTTOM w0.16: v1(65.79,44.12) 65.79,40.64 65.29,40.14 v1(65.29,39.32)
PTA7/FTM0_FLT2: length 62
  TOP w0.16: U7.83 v1(64.79,44.12) ; 64.29,40.98 v1(64.29,39.32)
  L3_INT_1 w0.191: 52.74,68.34 51.81,68.34 45.56,74.58 42.91,74.58 40.19,77.3 40.19,78.86 J2.5
  L3_INT_1 w0.203: v1(64.79,44.12) 63.95,43.29 58.94,43.29 57.79,44.44 57.79,64.95 55.62,67.12 54.28,67.12 53.06,68.34 52.74,68.34
  BOTTOM w0.16: v1(64.79,44.12) 64.79,40.91 64.29,40.41 v1(64.29,39.32)
PTA8/LPUART2_RX: length 3.2
  TOP w0.203: R131.1 TP15.1
  TOP w0.406: TP15.1 v1(25.29,62.24)
  BOTTOM w0.203: v1(25.29,62.24) 25.26,62.27 25.26,62.73 25.25,62.73 U500.6
PTA8/LPUART2_RX/LPSPI2_SOUT/FXI: length 148.9
  TOP w0.16: U8.176 82.3,64.44 82.58,64.71 v1(82.58,65.28) ; U7.144 v1(77.63,62.43)
  L6_INT_2 w0.191: 52.74,64.97 52.1,64.97 51.39,65.68 47.49,65.68 45.64,63.82 42.52,63.82 42,64.34 30.16,64.34 26.23,68.26 v1(25.08,68.26) 25.08,66.53 19.23,60.68 17.32,60.68 15.33,58.69 13.27,58.69 13.08,58.51 12.53,57.95 12.53,54.89 16.82,50.6 17.2,50.6 19.2,48.59 19.2,43.76 31.55,31.41 31.55,23.25 31.76,23.04 v1(31.76,22.57)
  L6_INT_2 w0.203: 52.74,64.97 54.97,64.97 55.33,64.6 77.09,64.6 79.5,67.02 80.84,67.02 v1(82.58,65.28)
  BOTTOM w0.16: v1(77.63,62.43) 78.43,62.43 80.95,64.95 82.25,64.95 v1(82.58,65.28)
  BOTTOM w0.203: v1(25.08,68.26) 25.41,67.93 R512.1
  BOTTOM w0.406: J3.20 41.87,25.36 32.17,25.36 31.76,24.95 v1(31.76,22.57)
PTA9/LPUART2_TX: length 3.7
  TOP w0.203: v1(24.61,62.49) 24.27,62.49 TP12.1 23.58,61.22 23.71,61.1 R130.1
  BOTTOM w0.203: U500.7 24.85,62.73 v1(24.61,62.49)
PTA9/LPUART2_TX/LPSPI2_PCS0/FXI: length 150.4
  TOP w0.16: U7.143 v1(78.1,61.93) ; v1(83.83,64.83) 82.94,63.94 U8.175
  L6_INT_2 w0.191: 52.74,65.34 52.73,65.32 52.6,65.32 52.56,65.28 52.23,65.28 51.52,65.99 47.39,65.99 46.4,66.98 45.27,66.98 43.32,65.03 30.36,65.03 26.34,69.05 24.73,69.05 v1(23.91,68.23) 23.91,66.34 21,63.42 16.69,63.42 16.09,62.82 16.09,59.9 15.2,59.01 13.14,59.01 12.76,58.64 12.76,58.64 12.21,58.08 12.21,57.82 12.21,57.82 12.21,54.76 16.69,50.28 17.06,50.28 18.88,48.46 18.88,42.48 28.79,32.57 v1(28.79,31.71)
  L6_INT_2 w0.203: 52.74,65.34 55.11,65.34 55.49,64.96 76.94,64.96 79.35,67.37 81.29,67.37 v1(83.83,64.83)
  BOTTOM w0.16: v1(78.1,61.93) 78.7,61.93 81.24,64.48 83.48,64.48 v1(83.83,64.83)
  BOTTOM w0.203: v1(23.91,68.23) 24.19,67.96 R511.1
  BOTTOM w0.406: J3.23 44.48,27.84 30.02,27.84 29.2,28.65 29.2,31.3 v1(28.79,31.71)
PTA10/FTM1_CH4/FXIO_D0/JTAG_TDO: length 24.2
  TOP w0.203: v1(82.44,58.43) U8.164 80.25,58.43 80.25,58.43 U7.136
  L3_INT_1 w0.191: v1(93.73,65.94) 93.4,65.61 93.07,65.61 92.09,64.63 85.11,64.63 84.4,63.92 83.93,63.92
  L3_INT_1 w0.203: v1(82.44,58.43) 81.95,58.92 81.95,63.64 82.24,63.92 83.93,63.92
  BOTTOM w0.406: R515.2 95.59,66.01 95.25,66.36 94.15,66.36 v1(93.73,65.94)
PTA11/FTM1_CH5/FXIO_D1/CMP0_RRT: length 67
  TOP w0.16: U8.163 v1(82.91,57.93)
  TOP w0.203: U7.135 80.25,57.93 80.25,57.93 U8.163
  TOP w0.406: J5.6 78.7,21.8 R324.1
  L3_INT_1 w0.191: 83.93,57.39 84.77,57.39 88.65,53.51 88.65,44.35 88.65,44.35 88.65,31.04 87.46,29.85 87.46,28.73 86.78,28.06 86.18,28.06 84.89,26.77 84.89,26.17 84.24,25.52 79.81,25.52 J5.6
  L3_INT_1 w0.203: 83.93,57.39 83.39,57.93 v1(82.91,57.93)
PTA12/FTM1_CH6/CAN1_RX/LPI2C1_S: length 60.9
  TOP w0.16: U8.162 v1(82.44,57.43)
  TOP w0.203: U8.162 80.25,57.43 80.25,57.43 U7.134
  TOP w0.406: J5.8 81.24,21.8 R325.1
  L3_INT_1 w0.191: 83.93,56.91 84.79,56.91 88.33,53.38 88.33,44.22 88.33,44.21 88.33,32.86 84.89,29.42 84.89,28.71 84.06,27.87 82.49,27.87 J5.8
  L3_INT_1 w0.203: 83.93,56.91 83.8,56.91 83.28,57.43 v1(82.44,57.43)
PTA13/FTM1_CH7/FTM2_QD_PHA/SAI0: length 106.3
  TOP w0.16: v1(82.45,54.71) 82.45,55.17 82.33,55.29 82.04,55.29 81.9,55.43 U8.158
  TOP w0.203: U7.130 80.25,55.43 80.25,55.43 U8.158
  TOP w0.406: R326.1 v1(73.37,12.33)
  L3_INT_1 w0.191: 83.93,52.96 84.88,52.02 84.88,44.55 85.62,43.82 85.62,34.36 v1(81.98,30.72) ; J1.23 47,78.65 47,77.1 48.49,75.61 48.55,75.61 50.51,73.65 53.17,73.65 55.51,71.31 55.51,69.75 56.21,69.05
  L3_INT_1 w0.203: 56.21,69.05 56.36,68.9 56.39,68.9 61.04,64.25 77.91,64.25 80.35,61.81 80.35,56.8 v1(82.45,54.71) 82.45,54.23 82.94,53.73 83.17,53.73 83.93,52.96
  BOTTOM w0.406: v1(73.37,12.33) 79.95,18.91 79.95,29.86 80.81,30.72 v1(81.98,30.72)
PTA14/FTM0_FLT0/FTM3_FLT1/SAI0_: length 114.5
  TOP w0.203: v1(82.54,53.38) 82.54,53.73 82.33,53.93 U8.155 80.25,53.93 80.25,53.93 U7.127
  TOP w0.406: R329.1 v1(80.99,12.33)
  L3_INT_1 w0.191: v1(80.99,12.33) 77.59,15.73 77.59,27.09 78.24,27.74 79.29,27.74 80.13,28.58 80.13,29.68 85.3,34.85 85.3,43.58 84.56,44.31 84.56,51.83 83.93,52.46
  L3_INT_1 w0.203: 83.93,52.46 83.02,53.38 v1(82.54,53.38)
  L6_INT_2 w0.191: 71.79,69.45 64.41,69.45 63.43,70.43 61.91,70.43 61.59,70.74 60.5,70.74 57.35,73.89 55.65,73.89 53.3,71.54 52.9,71.54 51.87,72.57 51.87,77.87 51.2,78.54 50.1,78.54 49.65,78.99 49.2,78.99 J1.20
  L6_INT_2 w0.203: v1(82.54,53.38) 83.68,53.38 85.63,55.33 85.63,64.78 81.54,68.87 72.73,68.87 72.16,69.45 71.79,69.45
PTA15: length 60.6
  TOP w0.203: 83.93,50.53 83.41,50.53 83.41,50.53 83.08,50.53 v1(82.84,50.76) 82.84,50.69 82.58,50.43 U8.148 80.25,50.43 80.25,50.43 U7.120
  TOP w0.406: R191.2 83.93,50.53 ; R304.2 v1(105.37,14.18)
  L3_INT_1 w0.191: v1(82.84,50.76) 81.96,49.88 81.96,43.05 84.09,40.92 84.09,37.91 84.03,37.86 84.03,37.77 82.54,36.29 82.54,33.52 v1(81.67,32.65)
  BOTTOM w0.406: v1(105.37,14.18) 103.52,16.04 96.46,16.04 87.57,24.93 87.57,30.19 85.1,32.65 v1(81.67,32.65)
PTA15/FTM1_CH2/ADC1_SE12: length 43.7
  TOP w0.406: v1(85.92,50.45) 85.84,50.53 R191.1
  BOTTOM w0.191: J4.21 67.11,25.2 68.67,25.2 71.83,28.37 71.83,30.57 74.81,33.55 79.57,33.55 80.32,34.3 84.16,34.3 88.23,38.37 88.23,45.58 85.45,48.36 85.45,49.99 v1(85.92,50.45)
PTA16: length 67.8
  TOP w0.16: v1(82.46,49.41) 82.45,49.41 82.44,49.43 U8.146 ; U7.119 v1(78.1,49.93)
  TOP w0.203: v1(82.46,49.41) 83.07,49.41 83.1,49.44 83.5,49.44 83.51,49.44 83.93,49.44
  TOP w0.406: R275.2 v1(104.48,34.77) ; R193.2 83.93,49.44
  L6_INT_2 w0.191: v1(86.44,53.25) 84.32,51.13 84.32,50.19 83.56,49.44 83.11,49.44 83.08,49.41 v1(82.46,49.41)
  BOTTOM w0.16: v1(82.46,49.41) 81.94,49.93 v1(78.1,49.93)
  BOTTOM w0.406: v1(86.44,53.25) 86.44,51.53 92.72,45.25 92.72,25.77 93.64,24.85 103.85,24.85 105.02,26.02 105.02,33.54 104.48,34.07 v1(104.48,34.77)
PTA16/FTM1_CH3/ADC1_SE13: length 41.4
  TOP w0.406: R193.1 v1(85.98,49.44)
  BOTTOM w0.191: J4.24 72.15,27.7 72.15,30.44 74.94,33.23 79.7,33.23 80.41,33.94 85.59,33.94 88.55,36.91 88.55,45.71 85.77,48.49 85.77,49.23 v1(85.98,49.44)
PTA17/FTM0_CH6/ENET_RESET: length 52.5
  TOP w0.16: 68.79,40.98 v1(68.79,39.79) ; U7.92 v1(69.29,44.59)
  TOP w0.406: v1(35.52,35.52) 34.93,34.92 R267.1 ; R261.1 58.41,36.15 v1(58.46,36.21)
  L3_INT_1 w0.191: 68.79,38.62 68.79,37 v1(69.56,36.23)
  L3_INT_1 w0.203: 68.79,38.62 v1(68.79,39.79)
  L6_INT_2 w0.191: v1(69.56,36.23) 66.75,36.23 66.73,36.25 66.34,36.25 64.81,34.73 63.01,34.73 61.2,36.53 61.2,36.72 60.43,37.49 59.74,37.49 v1(58.46,36.21) 58.03,35.78 55.78,35.78 55.16,35.16 53.38,35.16 52.75,34.54 49.38,34.54 48.75,33.9 47.19,33.9 46.67,34.42 41.2,34.42 41.15,34.37 37.74,34.37 36.59,35.52 v1(35.52,35.52)
  BOTTOM w0.16: v1(69.29,44.59) 69.29,40.29 v1(68.79,39.79)
