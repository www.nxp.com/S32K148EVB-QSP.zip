# Allegro board S32K148EVB_Q176_RevB_Layout.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
N16745986 on L5_PWR_2: 12.56,56.22 12.56,50.23 20.1,42.68 22.57,42.68 22.97,43.09 22.97,47.03 21.7,48.3 21.7,49.16 25.9,53.35 29.27,53.35 29.53,53.6 31.94,53.6 34.12,55.79 34.12,61.76 33.67,62.22 29.91,62.22 28.92,61.22 28.92,58.33 26.63,56.04 25.16,56.04 24.42,56.78 22.39,56.78 19.52,53.91 16.57,53.91 13.96,56.53 12.87,56.53

Small or netless copper shapes (teardrops, artwork): 1 on TOP, 1 on BOTTOM, 1 on L2_GND_1, 1 on L3_INT_1, 1 on L4_PWR_1, 1 on L5_PWR_2, 1 on L6_INT_2

## Text on the board
BOTTOM: 170-29643 REV D | 8 OF 14 | SECONDARY SIDE
Board Geometry/Soldermask Bottom: 12 OF 14 | SECONDARY SOLDERMASK
Ref Des/Silkscreen Bottom: ** | * | NC | GND | LIN | CANL | CANH | VBAT | P3V3 | 14 OF 14 | SECONDARY SILKSCREEN
User.Comments: 1 OF 1 | TEST PROBE | 1/1 | 1
TOP: 1 OF 14 | PRIMARY SIDE
Board Geometry/Soldermask Top: 9 OF 14 | PRIMARY SOLDERMASK
Ref Des/Silkscreen Top: LIN2 | LIN1 | CAN | L | VBAT | E | F | N | J | VDD | H | G | K | P5V0 | I | SAI AUDIO | VDD_MCU | M | B | VREFH_MCU | VDDA_MCU | A | DEBUG ETM | CORTEX | C | P3V3 | ADC POT | D | VSUP | WK-UP | BTN0 | BTN1 | SW4 | S32K148EVB-Q144 | S32K148EVB-Q176 | 11 OF 14 | PRIMARY SILKSCREEN
L2_GND_1: 2 OF 14 | GROUND PLANE 1
L3_INT_1: 3 OF 14 | INTERNAL 1
L4_PWR_1: 4 OF 14 | POWER PLANE 1
L5_PWR_2: 5 OF 14 | POWER PLANE 2
L6_INT_2: 6 OF 14 | INTERNAL 2
L7_GND_2: 7 OF 14 | GROUND PLANE 2
DIMENSION: 0 | PRIMARY DATUM | GRID ORIGIN
BODY_CENTER: 16 | 17 | 8
DISPLAY_TOP: 10 OF 14 | PASTEMASK TOP
User.5: 13 OF 14 | SECONDARY PASTEMASK
User.15: 07-17-17 | 01-30-18 | W.R. | B | C | SCHEMATIC CHANGED | CHANGES PER ECO75024
User.18: L8_SS | 16.00 | 50 | ---- | 9.00 | 5.00 | 90
User.24: FIGURE | SIZE | 10.0 | 15.0 | 28.0 | 31.0 | 40.0 | 44.0 | 45.0 | 47.0 | 63.0 | 100.0 | 125.0 | 34.0x26.0 | 60.0x33.0 | 111.0x32.0 | 122.0x32.0 | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILS | TOLERANCE | +0.0/-10.0 | +2.0/-2.0 | +3.0/-3.0 | PLATED | NON-PLATED | QTY | 1042 | 2 | 12 | 10 | 181 | 4 | 1 | 50 | 8 | 5 | 3
