# Allegro board S32K148EVB_Q176_RevB_Layout.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PTA18/FTM4_CH0/LPUART1_TX/LPSPI: length 14.8
  TOP w0.16: U8.1 v1(79.3,68.04)
  L3_INT_1 w0.191: v1(81.8,76.03) 82.33,75.51 82.33,71.58 79.79,69.05
  L3_INT_1 w0.203: v1(79.3,68.04) 79.3,68.55 79.79,69.05
  L6_INT_2 w0.191: v1(81.8,76.03) 80.78,76.03 80.46,76.36 79.78,76.36 J6.16
PTA19/FTM4_CH1/LPUART1_RX/LPSPI: length 12.1
  TOP w0.16: U8.2 v1(78.8,67.57)
  L3_INT_1 w0.191: J6.13 81.24,71.49 78.8,69.05
  L3_INT_1 w0.203: 78.8,69.05 v1(78.8,67.57)
PTA20/FTM4_CH2/LPSPI1_SIN: length 18.1
  TOP w0.16: U8.3 v1(78.3,68.04)
  L3_INT_1 w0.191: J6.15 80.13,81.4 80.13,76.71 80.68,76.17 80.68,74.81 77.88,72.01 77.88,69.13 77.97,69.05
  L3_INT_1 w0.203: v1(78.3,68.04) 78.3,68.71 77.97,69.05
PTA21/FTM4_CH3/FXIO_D0/LPSPI1_P: length 21.1
  TOP w0.16: U8.6 v1(76.8,67.57)
  L3_INT_1 w0.191: J6.12 82.65,81.37 82.65,70.71 81.01,69.07 80.8,69.07 80.77,69.05
  L3_INT_1 w0.203: 80.77,69.05 80.1,68.37 80.1,68.16 79.03,67.09 77.28,67.09 v1(76.8,67.57)
PTA22/FTM4_CH4/FXIO_D1/LPSPI1_P: length 25.5
  TOP w0.16: U8.9 v1(75.3,68.04)
  L3_INT_1 w0.191: 81.49,69.05 85.48,73.04 85.48,76.7 85.21,76.97 85.21,81.4 J6.9
  L3_INT_1 w0.203: v1(75.3,68.04) 75.3,67.39 75.95,66.74 79.18,66.74 80.45,68.01 80.45,68.23 80.95,68.72 81.16,68.72 81.49,69.05
PTA23/FTM4_CH6/FXIO_D2: length 29
  TOP w0.16: U8.13 v1(73.3,68.04)
  L3_INT_1 w0.191: J6.6 87.43,81.08 87.43,74.49 81.99,69.05
  L3_INT_1 w0.203: v1(73.3,68.04) 73.3,67.39 74.31,66.38 79.33,66.38 80.81,67.87 80.81,68.08 81.09,68.36 81.31,68.36 81.99,69.05
PTA24/FTM4_CH7/FXIO_D3: length 31.9
  TOP w0.16: U8.16 v1(71.79,67.57)
  L3_INT_1 w0.191: 83.93,68.92 85.72,70.71 85.72,70.82 86,71.1 86.11,71.1 90.29,75.28 90.29,81.4 J6.3
  L3_INT_1 w0.203: 83.93,68.92 81.04,66.03 73.34,66.03 v1(71.79,67.57)
PTA25/FTM5_CH0: length 81.2
  TOP w0.16: U7.10 v1(72.79,63.24) ; U8.17 v1(71.29,68.04)
  L6_INT_2 w0.191: v1(40.12,62.82) 39.18,62.82 37.71,61.36 37.71,55.27 40.53,52.45 v1(40.53,51.62) ; J2.2 40.52,78.87 40.52,76.97 41.18,76.32 42.94,76.32 51.68,67.58 52.74,67.58
  L6_INT_2 w0.203: 52.74,67.58 53.21,67.12 55.94,67.12 56.32,66.74 70.64,66.74 71.29,67.39 v1(71.29,68.04)
  BOTTOM w0.16: v1(72.79,63.24) 72.79,64.32 71.78,65.33 71.78,65.58 71.29,66.07 v1(71.29,68.04)
  BOTTOM w0.406: R552.1 v1(40.53,51.62) ; J2.2 42.84,78.75 42.84,76.43 41.03,74.63 41.03,63.74 v1(40.12,62.82)
PTA26/FTM5_CH1/LPSPI1_PCS0: length 144.7
  TOP w0.16: U7.19 v1(68.29,62.77) ; U8.26 v1(66.79,67.57)
  TOP w0.406: v1(57.65,20.03) 57.65,21.24 56.83,22.06 R283.1
  L3_INT_1 w0.191: v1(68.29,62.77) 69.66,61.4 73.8,61.4 79.65,55.56 79.65,54.08 81.26,52.47 81.26,42.76 83.34,40.68 83.34,38.14 81.65,36.44 81.65,34.29 80.4,33.04 v1(80.4,32.7) ; v1(26.48,32.15) 26.48,42.42 26.83,42.76 26.83,43.16 26.48,43.51 26.48,45.6 26.08,46 26.08,46.08 v1(25.74,46.42)
  L6_INT_2 w0.191: v1(57.65,20.03) 57.21,20.46 39.64,20.46 39.08,19.9 28.35,19.9 26.48,21.77 v1(26.48,32.15)
  BOTTOM w0.16: v1(66.79,67.57) 66.79,66.23 68.29,64.73 v1(68.29,62.77)
  BOTTOM w0.191: v1(80.4,32.7) 77.48,29.78 77.48,25.36 72.15,20.03 v1(57.65,20.03)
  BOTTOM w0.203: R564.1 26.05,46.64 25.82,46.42 v1(25.74,46.42)
PTA26/FTM5_CH1/LPSPI1_PCS0_LS: length 9.6
  TOP w0.406: v1(29.81,56.59) R149.1
  TOP w0.508: v1(29.81,56.59) 29.78,56.61 29.73,56.61 29.49,56.86 TP17.1
  BOTTOM w0.203: U507.6 26.56,50.84 27.01,51.29 27.37,51.29 29.81,53.73 v1(29.81,56.59)
PTA27/FTM5_CH2/LPSPI1_SOUT/LP_1: length 4.9
  TOP w0.406: v1(31.94,53.91) 31.43,53.4 TP22.1 30.29,53.4 R177.1
  BOTTOM w0.203: v1(31.94,53.91) 32.75,53.91 33.29,53.37 U506.6
PTA27/FTM5_CH2/LPSPI1_SOUT/LPUA: length 93.6
  TOP w0.16: U8.29 v1(65.29,68.04) ; U7.22 v1(66.79,63.24)
  L3_INT_1 w0.191: v1(34.73,48.85) 35.21,48.85 35.78,49.42 37.42,49.42 39.3,51.3 39.3,51.97 40.85,53.52 42.05,53.52 46.55,58.02 v1(46.77,58.02)
  L6_INT_2 w0.191: J4.6 51.87,25.52 49.1,25.52 47.97,26.65 47.97,28.43 45.81,30.6 35.92,30.6 33.01,33.51 32.56,33.51 30.7,35.38 29.14,36.93 29.14,42.97 34.4,48.23 34.4,48.52 v1(34.73,48.85) ; v1(46.77,58.02) 48.59,58.02 52.27,61.71 52.74,61.71
  L6_INT_2 w0.203: v1(66.79,63.24) 66.79,62.59 65.35,61.15 60.85,61.15 60.38,61.62 59.36,61.62 59.19,61.45 54.45,61.45 54.2,61.71 52.74,61.71
  BOTTOM w0.16: v1(65.29,68.04) 65.29,66.2 66.79,64.7 v1(66.79,63.24)
  BOTTOM w0.203: v1(34.73,48.85) R555.1
PTA28/FTM5_CH3/LPSPI1_SCK/LPU_1: length 10.2
  TOP w0.406: R150.1 29.91,54.82 30.57,55.48 v1(30.57,55.89) 30.92,55.89 31.15,56.12 TP21.1
  BOTTOM w0.203: v1(30.57,55.89) 30.23,55.55 30.23,53.57 27.57,50.91 27.18,50.91 26.96,50.7 U507.7
PTA28/FTM5_CH3/LPSPI1_SCK/LPUAR: length 126.8
  TOP w0.16: U7.24 v1(65.79,63.24) ; U8.31 v1(64.29,68.04)
  L6_INT_2 w0.191: J4.9 54.11,22.36 43.32,22.36 42.03,23.65 42.03,26.75 40.83,27.95 35.19,27.95 34.41,28.73 34.41,31.15 32.69,32.87 32.31,32.87 30.43,34.74 27.41,37.76 v1(27.41,42.24) 27.41,43.18 27.72,43.48 28.75,43.48 32.09,46.82 32.09,51.98 31.77,52.3 31.74,52.3 30.41,53.63 29.13,53.63 27.22,55.54 27.22,56.93 29.58,59.29 30.65,59.29 32.31,57.63 33.53,57.63 39.2,63.31 41.19,63.31 41.31,63.19 50.68,63.19 v1(51.09,63.6) ; v1(51.17,71) 52.83,69.34 54.51,69.34 54.72,69.12 57.13,69.12 57.79,69.78 61.19,69.78 61.58,69.4 62.94,69.4 v1(64.29,68.04)
  BOTTOM w0.16: v1(64.29,68.04) 64.29,66.25 65.79,64.75 v1(65.79,63.24)
  BOTTOM w0.191: v1(51.17,71) 51.62,70.55 51.62,64.13 v1(51.09,63.6)
  BOTTOM w0.406: R563.1 27.52,44.31 27.41,44.2 v1(27.41,42.24)
PTA29/FTM5_CH4/LPUART2_TX/LPS_1: length 5.5
  TOP w0.406: R154.1 30.39,54.52 TP25.1 32.27,54.52 33.08,53.71 33.66,53.71 v1(33.69,53.67)
  BOTTOM w0.203: U506.7 v1(33.69,53.67)
PTA29/FTM5_CH4/LPUART2_TX/LPSPI: length 113.2
  TOP w0.16: U7.26 v1(64.79,63.24) ; U8.33 v1(63.29,68.04)
  L3_INT_1 w0.191: v1(51.24,60.01) 46.29,60.01 41.61,55.33 39.16,55.33 38.65,54.82 37.86,54.82 37.71,54.97 36.37,54.97 36.09,54.69 36.09,53.83 36.66,53.25 36.66,51.68 v1(36.32,51.34)
  L6_INT_2 w0.191: J4.12 57.28,25.19 55.39,25.19 54.73,24.53 54.73,23.52 53.89,22.67 45.54,22.67 44.25,23.96 44.25,29.61 43.58,30.28 35.73,30.28 32.82,33.2 32.43,33.2 30.57,35.06 28.82,36.8 28.82,43.1 33.95,48.23 33.95,48.97 v1(36.32,51.34) ; v1(51.14,70.14) 52.29,68.99 52.74,68.99 ; 61.48,69.05 61.06,69.47 57.97,69.47 57.55,69.05
  L6_INT_2 w0.203: 52.74,68.99 54.36,68.99 54.61,68.74 57.25,68.74 57.55,69.05 ; 61.48,69.05 62.28,69.05 v1(63.29,68.04)
  BOTTOM w0.16: v1(64.79,63.24) 64.79,64.79 63.29,66.29 v1(63.29,68.04)
  BOTTOM w0.203: v1(36.32,51.34) 36.54,51.34 36.54,51.24 36.74,51.04 R554.1
  BOTTOM w0.406: v1(51.24,60.01) 51.24,60.59 50.51,61.33 50.51,65.4 51.14,66.04 v1(51.14,70.14)
PTA30/FTM5_CH5: length 56.8
  TOP w0.16: U7.27 v1(64.29,62.77) ; U8.34 v1(62.79,67.57)
  L3_INT_1 w0.191: 62.79,69.05 62.79,70.79 66.56,74.56 66.56,81.85 64.43,83.98 45.36,83.98 v1(43.69,82.31)
  L3_INT_1 w0.203: v1(62.79,67.57) 62.79,69.05
  L6_INT_2 w0.191: J2.4 40.19,78.54 40.19,80.11 41.16,81.08 42.08,81.08 42.24,80.92 43.21,80.92 43.69,81.39 v1(43.69,82.31)
  BOTTOM w0.16: v1(64.29,62.77) 64.29,64.81 62.79,66.32 v1(62.79,67.57)
PTA31/FTM5_CH6: length 39.7
  TOP w0.16: U8.40 v1(59.79,67.57) ; U7.33 v1(61.29,62.77)
  L3_INT_1 w0.191: v1(44.33,82.07) 45.01,81.4 48.81,81.4 49.65,80.56 49.65,75.4 50.7,74.36 53.43,74.36 55.78,72.01 55.78,72.01 55.96,71.82 55.97,71.82
  L3_INT_1 w0.203: 55.97,71.82 57.54,71.82 59.79,69.57 v1(59.79,67.57)
  L6_INT_2 w0.191: J2.1 44.33,80.14 v1(44.33,82.07)
  BOTTOM w0.16: v1(59.79,67.57) 59.79,65.99 61.29,64.49 v1(61.29,62.77)
PTB0/SBC_LPSPI0_PCS0: length 92
  TOP w0.16: U7.78 v1(62.29,44.59)
  TOP w0.203: 61.79,40.98 61.79,39.8 v1(61.8,39.78)
  BOTTOM w0.16: v1(61.8,39.78) 61.8,40.26 62.29,40.75 v1(62.29,44.59)
  BOTTOM w0.191: J2.7 37.64,78.53 37.64,82.96 36.69,83.91 26.22,83.91 24.96,82.65 24.96,71.53 39.33,57.16 39.46,57.16 46.44,50.18 46.44,48.83 46.84,48.43 46.84,46.88 52.72,41.01 54.22,41.01 57.11,38.11 59.77,38.11 59.78,38.12 60.7,38.12 60.71,38.11 60.75,38.11 61.79,39.15 61.79,39.3 61.8,39.31 v1(61.8,39.78)
PTB1/LPSPI0_SOUT: length 67.2
  TOP w0.16: v1(61.29,39.32) 61.29,39.78 61.29,39.79 61.29,40.98 ; U7.77 v1(61.79,44.12)
  L3_INT_1 w0.191: J2.10 35.11,78.54 35.11,80.09 36.08,81.07 42.07,81.07 43.12,80.02 43.12,77.49 51.56,69.05 52.74,69.05
  L3_INT_1 w0.203: v1(61.79,44.12) 61.31,43.64 59.09,43.64 58.15,44.58 58.15,65.1 55.77,67.47 54.43,67.47 52.85,69.05 52.74,69.05
  BOTTOM w0.16: v1(61.79,44.12) 61.79,40.83 61.29,40.33 v1(61.29,39.32)
PTB2/LPSPI0_SCK: length 76.1
  TOP w0.16: U7.68 v1(58.98,46.93) ; U8.78 v1(54.65,47.93)
  L6_INT_2 w0.191: v1(38.98,74.93) 38.5,74.93 38.44,74.99 31.36,74.99 J2.16
  BOTTOM w0.16: v1(54.65,47.93) 57.99,47.93 v1(58.98,46.93)
  BOTTOM w0.191: v1(54.65,47.93) 54.01,47.93 52.95,48.99 52.95,52.33 50.36,54.93 50.36,60.36 49.75,60.96 49.75,65.88 50.34,66.46 50.34,73.4 51.76,74.83 51.76,75.45 51.36,75.85 50.32,75.85 49.33,76.84 49.33,82.97 48.68,83.62 41.16,83.62 40.51,82.97 40.51,76.65 39.31,75.46 39.31,75.27 v1(38.98,74.93)
PTB3/LPSPI0_SIN: length 72.4
  TOP w0.16: U7.63 v1(59.45,49.43) ; U8.73 v1(54.18,50.43)
  L6_INT_2 w0.191: v1(38.44,75.47) 38.11,75.8 33.08,75.8 J2.13
  BOTTOM w0.16: v1(59.45,49.43) 56.54,49.43 55.54,50.43 v1(54.18,50.43)
  BOTTOM w0.191: v1(38.44,75.47) 38.78,75.8 39.12,75.8 40.19,76.87 40.19,83.1 41.03,83.94 48.81,83.94 49.65,83.1 49.65,76.97 50.45,76.17 51.49,76.17 52.11,75.56 52.11,74.56
  BOTTOM w0.203: 52.11,74.56 50.66,73.11 50.66,66.33 50.08,65.74 50.08,61.1 50.68,60.5 50.68,55.14 53.33,52.48 53.33,51.09 53.99,50.43 v1(54.18,50.43)
PTB4/MII_RMII_MDIO: length 104
  TOP w0.406: v1(103.29,73.23) 103.31,73.23 103.71,73.62 R46.2 ; R268.2 v1(39.18,32.56)
  L6_INT_2 w0.191: v1(39.18,32.56) 39.18,32.08 39.9,31.36 51.09,31.36 51.49,31.76 56.95,31.76 57.16,31.55 60.46,31.55 60.54,31.47 78.14,31.47 78.39,31.22 85.25,31.22 99.63,45.6 99.63,50.47 100.09,50.93 102.17,50.93 107.89,56.66 107.89,69.1 103.77,73.23 v1(103.29,73.23)
PTB4/MII_RMII_MDIO/QSPI_B_IO0: length 49.5
  TOP w0.16: U8.49 v1(54.18,62.44) ; U7.41 v1(59.45,60.43)
  TOP w0.406: R227.1 36.06,42.25 36.03,42.27 v1(34.89,42.27)
  L3_INT_1 w0.191: v1(34.89,42.27) 34.41,42.27 33.79,42.9 33.79,50.25 35.78,52.24 35.78,53.23 34.99,54.02 34.99,56.88 36.35,58.23 39.17,58.23 43.38,62.44 52.74,62.44
  L3_INT_1 w0.203: v1(54.18,62.44) 52.74,62.44
  BOTTOM w0.16: v1(59.45,60.43) 57.44,60.43 55.44,62.44 v1(54.18,62.44)
PTB4/MII_RMII_MDIO/QSPI_B_IO0_1: length 4.1
  TOP w0.279: U14.2 38.84,36.08 38.84,36.08 38.84,36.07 38.7,35.93 v1(38.7,35.41) 38.7,34.81 R268.1
  BOTTOM w0.279: v1(38.7,35.41) 38.7,34.81 R268.1
PTB4/MII_RMII_MDIO/QSPI_B_IO0__: length 3.3
  TOP w0.279: v1(37.98,41.39) 38.35,41.02 38.39,41.02 38.84,40.57 U14.13
  TOP w0.406: v1(37.98,41.39) 37.96,41.39 38.04,41.46 R227.2
  BOTTOM w0.279: v1(37.98,41.39) 37.96,41.39 38.04,41.47 38.04,41.85 R572.2
PTB5/ENET_MII_RMII_MDC: length 104.9
  TOP w0.279: U22.2 65.75,34.52 65.76,34.5 65.76,33.98 66,33.74 v1(66.52,33.74) R273.2
  TOP w0.406: R38.2 103.52,74.64 102.6,73.72 v1(102.6,73.14)
  L6_INT_2 w0.191: v1(102.6,73.14) 102.6,72.44 102.7,72.35 103.04,72.35 103.13,72.26 103.13,72.12 103.04,72.03 102.7,72.03 102.6,71.94 102.6,71.81 102.7,71.71 103.04,71.71 103.13,71.62 103.13,71.49 103.04,71.4 102.7,71.4 102.6,71.3 102.6,71.09 102.51,71 102.13,71 102.03,71.09 102.03,73.25 101.94,73.34 101.81,73.34 101.72,73.25 101.72,71.09 101.62,71 101.49,71 101.4,71.09 101.4,73.25 101.31,73.34 101.17,73.34 101.08,73.25 101.08,72.55 100.99,72.45 100.33,72.45 100.23,72.36 100.23,72.23 100.33,72.14 100.99,72.14 101.08,72.04 101.08,71.91 100.99,71.82 100.33,71.82 100.23,71.73 100.23,71.6 100.33,71.5 100.99,71.5 101.08,71.41 101.08,71.09 100.99,71 99.92,71 99.82,71.09 99.82,71.88 99.73,71.97 99.6,71.97 99.51,71.88 99.51,71.09 99.41,71 98.68,71 98.59,70.91 98.59,70.77 98.68,70.68 99.45,70.68 99.54,70.59 99.54,70.13 99.64,70.04 99.77,70.04 99.86,70.13 99.86,70.59 99.95,70.68 100.09,70.68 100.18,70.59 100.18,70.13 100.27,70.04 100.4,70.04 100.5,70.13 100.5,70.59 100.59,70.68 100.72,70.68 100.81,70.59 100.81,70.13 100.91,70.04 101.04,70.04 101.13,70.13 101.13,70.59 101.22,70.68 102.51,70.68 102.6,70.59 102.6,70.27 102.51,70.18 101.64,70.18 101.55,70.08 101.55,69.95 101.64,69.86 102.51,69.86 102.6,69.77 102.6,69.64 102.51,69.54 101.64,69.54 101.55,69.45 101.55,69.32 101.64,69.23 102.51,69.23 102.6,69.13 102.6,69 102.51,68.91 101.64,68.91 101.55,68.81 101.55,68.68 101.64,68.59 102.51,68.59 102.6,68.5 102.6,68.34 103.16,67.78 103.16,64.66 102.51,64.01 102.51,62.32 104.06,60.77 104.06,57.64 101.01,54.59 101.01,54.46 100.17,53.62 98.52,53.62 92.72,47.83 92.72,47.81 91.47,46.55 91.47,42.82 84.39,35.74 84.39,35.08 84.11,34.8 83.45,34.8 83.44,34.8 80.81,34.8 79.71,33.7 79.32,33.7 78.8,34.22 68.99,34.22 68.52,33.74 v1(66.52,33.74)
PTB5/MII_RMII_MDC: length 89.2
  TOP w0.16: U7.40 v1(58.98,60.93) ; U8.48 v1(54.65,62.94)
  L3_INT_1 w0.191: v1(51.09,62.91) 51.74,63.56 54.15,63.56 54.65,63.06 v1(54.65,62.94)
  L6_INT_2 w0.191: v1(51.09,62.91) 50.44,62.27 40.14,62.27 38.63,60.75 38.63,55.92 39.38,55.17 39.4,55.17 39.68,54.89 39.68,53.75 41,52.43 41,50.33 40.77,50.1 40.77,48.73 38.73,46.7 35.36,46.7 29.78,41.11 29.78,37.2 32.48,34.49 35.18,34.49 36.63,33.04 39.38,33.04 39.66,32.76 39.66,32.43 40.4,31.68 50.96,31.68 51.36,32.08 56.01,32.08 56.7,32.77 57.12,32.77 57.52,32.37 v1(58.64,32.37)
  BOTTOM w0.16: v1(54.65,62.94) 55.41,62.94 57.42,60.93 v1(58.98,60.93)
  BOTTOM w0.406: R604.1 v1(58.64,32.37)
PTB5/MII_RMII_MDC__A: length 3.6
  TOP w0.279: v1(60.6,33.93) 60.6,34.1 60.83,34.34 60.83,34.43 60.92,34.52 U22.13
  BOTTOM w0.406: R604.2 60.19,33.93 v1(60.6,33.93) 60.99,33.54 R603.2
PTB6_XTAL: length 16.5
  TOP w0.16: U8.25 v1(67.29,68.04) ; U7.18 v1(68.79,63.24)
  TOP w0.229: R64.2 R76.2 67.02,68.32 v1(67.29,68.04) ; R64.2 66.26,70.32 66,70.06 R76.1 ; R64.2 67.02,70.51 66.53,71 Y1.2 C3.1
  BOTTOM w0.16: v1(67.29,68.04) 67.29,66.23 68.79,64.73 v1(68.79,63.24)
PTB7_EXTAL: length 17.2
  TOP w0.16: U7.17 v1(69.29,62.77) ; U8.24 v1(67.79,67.57)
  TOP w0.229: v1(67.79,67.57) 67.79,68.5 68.03,68.74 R78.2 R64.1 ; R64.1 68.53,70.81 Y1.1 C4.1 ; R64.1 68.69,70.32 69.05,69.96 R78.1
  BOTTOM w0.16: v1(69.29,62.77) 69.29,64.79 67.79,66.29 v1(67.79,67.57)
PTB8/FTM3_CH0/SAI1_BCLK: length 64.7
  TOP w0.16: U7.111 v1(78.1,45.93) ; U8.136 v1(82.91,44.42)
  TOP w0.406: J5.4 63.18,13.65 55.31,13.65 R318.1
  L3_INT_1 w0.203: J5.4 74.94,27.85 73.36,27.85 72.5,28.71 72.5,29.63 77.51,34.64 78.6,34.64 79.07,35.11 79.07,37.69 80.57,39.19 80.57,40.18 78.96,41.8 78.96,45.56 78.58,45.93 v1(78.1,45.93)
  BOTTOM w0.16: v1(82.91,44.42) 80.72,44.42 79.21,45.93 v1(78.1,45.93)
PTB9/FTM3_CH1/LPI2C0_SCLS: length 107.2
  TOP w0.16: U8.133 82.31,42.92 82.33,42.9 v1(82.8,42.9) ; U7.109 v1(78.1,44.93)
  TOP w0.203: v1(82.8,42.9) 83.52,42.9 83.55,42.92 83.93,42.92
  TOP w0.406: R192.1 v1(89.73,50.12) 89.73,45.5 89.32,45.1 86.93,45.1 84.76,42.92 83.93,42.92 ; R319.1 v1(55.59,12.35)
  L3_INT_1 w0.191: v1(55.59,12.35) 56.05,11.9 62.1,11.9 75.29,25.08 76.18,25.08 77.27,26.17 77.27,27.22 78.11,28.06 79.16,28.06 79.81,28.71 79.81,29.93 84.84,34.95 84.84,36.62 84.35,37.12 84.35,37.72 84.51,37.88 84.51,42.03 83.93,42.61
  L3_INT_1 w0.203: 83.93,42.61 83.64,42.9 v1(82.8,42.9)
  L6_INT_2 w0.191: J6.10 85.81,75.4 v1(91.22,75.4)
  BOTTOM w0.16: v1(78.1,44.93) 80.21,42.82 82.25,42.82 82.33,42.9 v1(82.8,42.9)
  BOTTOM w0.406: v1(89.73,50.12) 89.17,50.68 89.17,51.73 90.51,53.07 90.51,74.69 v1(91.22,75.4)
PTB10/FTM3_CH2/LPI2C0_SDAS: length 153.3
  TOP w0.16: 78.8,40.98 v1(78.8,39.32) ; v1(77.48,44.16) 77.46,44.16 77.46,44.16 77.29,43.99 U7.108
  TOP w0.406: R187.1 v1(89.75,51.14) ; R315.1 v1(45.43,12.14)
  L3_INT_1 w0.191: v1(89.75,51.14) 90.28,50.61 90.28,29.77 90.29,29.76 90.29,28.58 90.28,28.56 90.28,20.95 81.19,11.85 67.77,11.85 66.82,12.81 64.93,12.81 63.7,11.58 53.57,11.58 52.32,12.83 46.12,12.83 v1(45.43,12.14)
  L6_INT_2 w0.191: v1(89.75,51.14) 90.2,50.69 90.2,48.43 89.21,47.44 89.21,43.9 85.29,39.99 83.93,39.99
  L6_INT_2 w0.203: v1(78.8,39.32) 79.14,38.98 79.67,38.98 80.68,39.99 83.93,39.99
  BOTTOM w0.16: v1(77.48,44.16) 78.8,42.83 v1(78.8,39.32)
  BOTTOM w0.406: J6.7 85.1,78.65 85.1,80.47 85.82,81.19 91.91,81.19 92.62,80.47 92.62,71.84 91.73,70.95 91.73,53.12 v1(89.75,51.14)
PTB11/FTM3_CH3/LPI2C0_HREQ: length 86.9
  TOP w0.16: U7.107 v1(76.79,44.15) ; 77.3,40.98 v1(77.3,39.79)
  L3_INT_1 w0.191: 52.74,65.66 52.69,65.66 45.11,73.24 31.56,73.24 27.82,76.97 27.82,78.87 J2.17
  L3_INT_1 w0.203: 52.74,65.66 55.07,65.66 56.37,64.36 56.37,43.85 58.35,41.86 74.53,41.86 76.45,43.78 76.45,43.81 v1(76.79,44.15)
  BOTTOM w0.16: v1(77.3,39.79) 77.3,43.62 77.12,43.8 77.12,43.83 v1(76.79,44.15)
PTB12/FTM0_CH0/FTM3_FLT2/CAN2_R: length 95.5
  TOP w0.16: U7.98 v1(72.29,44.59) ; 72.8,40.98 v1(72.8,39.32)
  L3_INT_1 w0.191: 52.74,66.86 51.94,66.86 45.23,73.57 33.76,73.57 30.35,76.99 30.35,80.09 29.37,81.07 28.46,81.07 27.8,80.41 27.8,79.84 26.52,78.55 20.17,78.55 J2.29
  L3_INT_1 w0.203: 52.74,66.86 53.59,66.02 55.21,66.02 56.72,64.51 56.72,43.99 58.5,42.22 70.57,42.22 72.29,43.94 v1(72.29,44.59)
  BOTTOM w0.16: v1(72.8,39.32) 72.8,40.41 72.29,40.91 v1(72.29,44.59)
PTB13/FTM0_CH1/FTM3_FLT1/CAN2_T: length 83.1
  TOP w0.16: 72.29,40.98 v1(72.29,39.79) ; U7.97 v1(71.79,44.12)
  BOTTOM w0.16: 71.79,40.29 v1(72.29,39.79)
  BOTTOM w0.191: v1(72.29,39.79) 72.29,39.01 72.62,38.68 72.62,38.47 72.66,38.43 72.66,38.04 72.62,38 72.62,37.93 72.32,37.62 65.44,37.62 64.94,37.11 63.05,37.11 62.76,37.41 60.96,37.41 60.57,37.8 59.91,37.8 59.9,37.79 56.94,37.79 54.08,40.65 ; J2.26 22.41,78.86 22.41,75.1 23.18,74.32 23.18,72.86 39.2,56.84 39.31,56.84 46.11,50.04 46.11,48.7 46.52,48.29
  BOTTOM w0.203: v1(71.79,44.12) 71.79,40.29 ; 54.08,40.65 52.59,40.65 46.52,46.72 46.52,48.29
PTB14/FTM0_CH2/LPSPI1_SCK/ADC1_: length 32.6
  TOP w0.16: U7.96 v1(71.29,44.59) ; 71.29,40.98 v1(71.29,39.79)
  TOP w0.203: v1(71.29,39.79) 71.29,39.02 71.59,38.72 73.16,38.72
  TOP w0.406: J5.15 88.02,32.55 83.64,32.55 80.17,36.03 75.86,36.03 73.16,38.72
  BOTTOM w0.16: v1(71.29,44.59) 71.29,40.25 71.29,40.25 v1(71.29,39.79)
PTB15/FTM0_CH3/LPSPI1_SIN/ADC1_: length 37.3
  TOP w0.16: 70.79,40.98 v1(70.79,39.32) ; U7.95 v1(70.79,44.12)
  TOP w0.203: 71.01,38.62 70.79,38.83 v1(70.79,39.32)
  TOP w0.406: 71.01,38.62 71.31,38.32 71.31,38.19 78.17,31.33 86.53,31.33 87.59,30.26 87.59,28.73 87.64,28.68 87.64,28.66 88.36,27.95 88.37,27.95 88.4,27.93 92.7,27.93 J5.17
  BOTTOM w0.16: v1(70.79,44.12) 70.79,39.78 70.79,39.78 v1(70.79,39.32)
PTB16: length 10.2
  TOP w0.16: U7.94 v1(70.29,44.61)
  TOP w0.203: 70.29,40.98 v1(70.29,39.79)
  BOTTOM w0.16: v1(70.29,39.79) 70.29,40.25 70.29,40.25 v1(70.29,44.61)
  BOTTOM w0.203: v1(70.29,39.79) 70.29,39.14 70.5,38.93 70.5,38.62
  BOTTOM w0.406: v1(70.29,44.61) 70.27,44.64 R634.2 ; R635.2 70.5,38.31 70.5,38.62
PTB16/FTM0_CH4/LPSPI1_SOUT/ADC1: length 31.4
  TOP w0.203: v1(81.8,38.82) 81.8,38.62
  TOP w0.406: J5.19 93.76,31.89 90.29,31.89 89.07,33.11 83.97,33.11 81.88,35.2 81.88,38.26 81.8,38.34 81.8,38.62
  L6_INT_2 w0.191: 73.04,38.62 72.66,38.24 v1(72.19,38.24)
  L6_INT_2 w0.203: 73.04,38.62 73.05,38.62 81.6,38.62 v1(81.8,38.82)
  BOTTOM w0.406: R635.1 v1(72.19,38.24)
PTB17/FTM0_CH5/LPSPI1_PCS3/FTM5: length 116.9
  TOP w0.16: U7.93 v1(69.79,44.12) ; 69.29,40.98 v1(69.29,39.32)
  TOP w0.406: R287.1 v1(48.81,19.72) ; v1(69.38,30.92) 69.79,30.51 69.79,22.95 65.87,19.04 v1(65.29,19.04)
  L3_INT_1 w0.191: 52.74,67.38 51.87,67.38 45.35,73.9 35.97,73.9 32.57,77.3 32.57,78.86 J2.14 ; 69.37,38.62 70.03,37.95 70.03,35.42 69.38,34.77 v1(69.38,30.92)
  L3_INT_1 w0.203: v1(69.79,44.12) 68.24,42.57 58.65,42.57 57.08,44.14 57.08,64.66 55.36,66.37 53.75,66.37 52.74,67.38 ; v1(69.29,39.32) 69.29,38.69 69.37,38.62
  L6_INT_2 w0.191: v1(65.29,19.04) 57.09,19.04 56.06,20.06 49.14,20.06 v1(48.81,19.72)
  BOTTOM w0.16: v1(69.29,39.32) 69.79,39.82 v1(69.79,44.12)
PTB18/FTM5_CH7/LPSPI1_PCS1/ADC0: length 50
  TOP w0.16: U8.43 58.28,67.98 58.31,68.01 58.31,68.16 58.33,68.19 58.46,68.19 v1(58.94,68.67) ; U7.36 v1(59.79,63.24)
  L3_INT_1 w0.191: 58.57,69.05 57.89,69.72 57.89,70.75 57.29,71.35 55.97,71.35 55.65,71.68 55.65,71.69 53.34,74 50.6,74 49.33,75.27 49.33,80.43 48.68,81.08 44.25,81.08 42.73,82.6 42.73,82.97 42.08,83.62 33.54,83.62 32.89,82.97 32.89,81.08 J2.11
  L3_INT_1 w0.203: 58.57,69.05 v1(58.94,68.67)
  BOTTOM w0.16: v1(58.94,68.67) 58.46,68.19 58.33,68.19 58.31,68.16 58.31,64.72 v1(59.79,63.24)
PTB19/FTM5_CH7: length 30.5
  TOP w0.16: v1(57.85,68.16) 57.85,67.7 57.78,67.63 U8.44
  BOTTOM w0.203: 58.15,69.05 57.85,68.75 v1(57.85,68.16)
  BOTTOM w0.406: 58.15,69.05 58.6,69.5 63.41,69.5 67.02,73.11 67.02,82.34 67.06,82.38 67.06,82.74 67.06,82.75 68.04,83.73 72.4,83.73 J6.24
PTB20/FTM6_CH0/ADC0_SE17: length 106.1
  TOP w0.16: U7.37 59.45,62.43 v1(59.62,62.26) ; v1(53.96,64.48) 54.73,64.48 54.78,64.44 U8.45
  TOP w0.406: v1(57.87,33.3) 57.87,33.94 R265.1
  L3_INT_1 w0.191: 55.29,54.1 55.29,47.89 54.85,47.45 54.5,47.45 52.93,45.88 52.93,45.44 53.6,44.77 53.6,43.21 53.94,42.87 53.94,42.07 51.63,39.76 51.63,38.31 53.76,36.18 53.76,36.01 56.81,32.97 57.54,32.97 v1(57.87,33.3)
  L3_INT_1 w0.203: 55.29,54.1 55.29,63.95 54.76,64.48 v1(53.96,64.48)
  L6_INT_2 w0.191: J6.1 90.13,78.7 90.13,83.12 89.4,83.86 68.19,83.86 66.03,81.7 v1(66.03,80.5)
  BOTTOM w0.16: v1(59.62,62.26) 57.4,64.48 v1(53.96,64.48)
  BOTTOM w0.203: v1(53.96,64.48) 55.61,66.13 55.61,67.37 57.3,69.05
  BOTTOM w0.406: v1(66.03,80.5) 66.03,77.78 66,77.75 66,74.03 62.49,70.52 58.77,70.52 57.3,69.05
PTB20/FTM6_CH0/ADC0_SE17__A: length 3.7
  TOP w0.279: v1(60.31,34.55) 60.31,34.73 60.6,35.02 U22.12
  TOP w0.406: R265.2 60.06,34.48 60.13,34.55 v1(60.31,34.55)
  BOTTOM w0.406: v1(60.31,34.55) 60.82,34.55 60.9,34.48 R597.2
PTB20/FTM6_CH0/ENET_INT: length 104.9
  TOP w0.279: R263.2 66.9,34.76 66.8,34.66 66.72,34.66 66.46,34.4 66.46,34.42 v1(66.46,34.42) 65.86,35.02 U22.3
  TOP w0.406: R5.2 102.88,77.68 102.31,77.11 v1(102.31,76.44)
  L6_INT_2 w0.191: v1(66.46,34.42) 68.61,34.42 68.84,34.65 79.54,34.65 80.32,35.43 81.34,35.43 82.28,36.37 82.56,36.37 83.3,37.11 83.95,37.11 84.02,37.05 85.05,37.05 91.15,43.15 91.15,46.69 92.41,47.94 92.41,47.96 98.39,53.94 100.04,53.94 100.69,54.59 100.69,54.72 103.75,57.77 103.75,60.61 102.19,62.16 102.19,65.33 102.48,65.62 102.48,66.48 101.78,67.18 100.72,67.18 100.63,67.27 100.63,67.77 100.72,67.86 102.13,67.86 102.22,67.96 102.22,68.09 102.13,68.18 100.72,68.18 100.63,68.27 100.63,69.01 100.53,69.1 100.4,69.1 100.31,69.01 100.31,67.27 100.22,67.18 100.08,67.18 99.99,67.27 99.99,69.01 99.9,69.1 99.77,69.1 99.67,69.01 99.67,67.27 99.58,67.18 99.45,67.18 99.36,67.27 99.36,69.01 99.26,69.1 99.13,69.1 99.04,69.01 99.04,68.48 98.95,68.38 98.38,68.38 98.29,68.29 98.29,68.16 98.38,68.07 98.95,68.07 99.04,67.97 99.04,67.27 98.95,67.18 98.63,67.18 95.68,70.13 95.68,71.28 96.56,72.16 96.69,72.16 97.32,71.53 97.45,71.53 97.54,71.62 97.54,71.75 96.91,72.38 96.91,72.51 97.01,72.61 97.14,72.61 97.77,71.98 97.9,71.98 97.99,72.07 97.99,72.2 97.36,72.83 97.36,72.96 97.45,73.06 97.59,73.06 98.22,72.43 98.35,72.43 98.44,72.52 98.44,72.65 97.81,73.28 97.81,73.41 98.45,74.05 98.82,74.05 98.92,73.96 98.92,73.42 99.01,73.33 99.14,73.33 99.23,73.42 99.23,73.96 99.33,74.05 99.92,74.05 v1(102.31,76.44)
PTB21/FTM6_CH1/ADC0_SE18: length 49.4
  TOP w0.16: U7.38 v1(58.98,61.93) ; v1(54.57,63.99) 54.62,63.99 54.62,63.99 54.68,63.94 U8.46
  L3_INT_1 w0.191: v1(80.3,66.53) 81.05,66.53 85.4,70.88 85.4,70.95 85.87,71.42 85.94,71.42 88.86,74.34 J6.4
  L6_INT_2 w0.203: v1(54.57,63.99) 54.78,64.2 77.18,64.2 79.52,66.53 v1(80.3,66.53)
  BOTTOM w0.16: v1(54.57,63.99) 56.93,63.99 v1(58.98,61.93)
PTB22/FTM6_CH2/MII_CRS/LPUART1_: length 55.3
  TOP w0.16: U8.66 v1(54.65,53.93) ; U7.58 v1(58.98,51.93)
  L3_INT_1 w0.191: v1(54.65,53.93) 50.76,53.93 47.56,50.73 47.56,45.36 45.66,43.47 45.66,39.92 46.74,38.84 46.74,37.27 47.28,36.73 47.28,34.95 44.46,32.13 44.46,28.94 43.58,28.06 31.87,28.06 J3.5
  BOTTOM w0.16: v1(58.98,51.93) 57.43,51.93 55.43,53.93 v1(54.65,53.93)
PTB23/FTM6_CH3/LPUART1_RX/MII_C: length 59.3
  TOP w0.16: U8.68 v1(54.65,52.93) ; U7.60 v1(58.98,50.93)
  TOP w0.406: v1(47.28,27.98) 46.21,27.98 46.19,27.95 29.22,27.95 J3.2
  L3_INT_1 w0.191: v1(54.65,52.93) 50.66,52.93 48.26,50.53 48.26,41.96 46.92,40.62 46.92,39.56 47.37,39.11 47.37,37.53 47.97,36.93 47.97,35.88 48.71,35.14 48.71,34.38 47.37,33.04 47.37,28.06 v1(47.28,27.98)
  BOTTOM w0.16: v1(54.65,52.93) 55.32,52.93 57.32,50.93 v1(58.98,50.93)
PTB24/FTM6_CH4: length 38.3
  TOP w0.16: U8.69 v1(54.18,52.43)
  BOTTOM w0.203: J1.18 51.88,83.63 53.76,83.63 54.42,82.97 54.42,76.97 52.87,75.42 52.87,73.63 52.44,73.2 52.44,68.15 52.39,68.1 52.39,67.81 52.39,63.76 52.26,63.64 52.26,54.65 54.18,52.73 v1(54.18,52.43)
PTB25/FTM6_CH5/LPSPI2_PCS0/ADC0: length 124.2
  TOP w0.16: U8.71 v1(54.18,51.43) ; U7.62 v1(58.98,49.93)
  TOP w0.406: R218.1 v1(99.4,41.74) ; v1(40.6,21.26) 40.6,21.84 41.87,23.11 41.87,25.36 J3.17
  L3_INT_1 w0.191: J3.17 41.7,27.73 46.54,27.73 46.77,27.5 47.48,27.5 47.76,27.78 47.76,32.98 49.03,34.25 49.03,35.27 48.29,36.01 48.29,37.06 47.69,37.66 47.69,39.24 47.24,39.69 47.24,40.45 48.58,41.79 48.58,45.98 52.74,50.15
  L3_INT_1 w0.203: 52.74,50.15 53.3,50.71 53.46,50.71 v1(54.18,51.43)
  L6_INT_2 w0.191: v1(40.6,21.26) 88.85,21.26 92.65,25.05 92.65,34.99 v1(99.4,41.74)
  BOTTOM w0.16: v1(54.18,51.43) 55.3,51.43 56.8,49.93 v1(58.98,49.93)
PTB26/FTM6_CH6: length 35.1
  TOP w0.16: U8.72 v1(54.65,50.93)
  BOTTOM w0.203: v1(54.65,50.93) 54,50.93 53.69,51.24 53.69,52.71 51.93,54.47 51.93,63.5 51.93,63.5 51.93,63.77 51.93,63.81 52.06,63.94 52.06,67.67 52.06,68.24 52.11,68.29 52.11,73.87 52.44,74.2 52.44,76.24 52.18,76.49 52.18,81.39 J1.15
PTB27/FTM6_CH7/LPSPI2_SOUT/ADC0: length 135.9
  TOP w0.16: U7.64 v1(58.98,48.93) ; U8.74 v1(54.65,49.93)
  TOP w0.406: R221.1 v1(102.45,41.74)
  L3_INT_1 w0.191: J3.11 36.79,25.36 36.79,23.81 37.7,22.9 47.33,22.9 47.93,23.5 47.93,23.84 49.35,25.26 49.35,31.97 50.99,33.61 50.99,41.68
  L3_INT_1 w0.203: v1(54.65,49.93) 54.22,49.5 54.22,49.37 53.7,48.85 53.7,47.72 53.78,47.63 53.78,47.23 52.57,46.01 52.57,45.31 53.25,44.62 53.25,43.94 50.99,41.68
  L6_INT_2 w0.191: v1(102.45,41.74) 102.45,41.85 101.76,42.54 99.34,42.54 99.34,42.54 99.07,42.54 90.15,33.62 89.97,33.43 89.97,31.85 87.75,29.63 87.75,23.05 86.73,22.04 41.1,22.04 39.49,23.65 39.49,24.66 38.64,25.52 36.63,25.52 J3.11
  BOTTOM w0.16: v1(58.98,48.93) 56.53,48.93 55.53,49.93 v1(54.65,49.93)
PTB28/FTM7_CH0/LPSPI2_SIN/ADC0_: length 148.3
  TOP w0.16: v1(53.73,49.57) 54.19,49.57 54.33,49.43 U8.75 ; U7.65 v1(59.45,48.43)
  TOP w0.406: J3.14 36.84,25.41 36.84,22.74 38.34,21.24 v1(38.93,21.24) ; v1(100.42,50.14) R183.1
  L3_INT_1 w0.191: 52.74,48.58 49.23,45.06 49.23,41.31 48.38,40.46 48.38,37.44 49.4,36.42 49.4,34.17 48.08,32.84 48.08,27.47 46.14,25.53 39.16,25.53 J3.14
  L3_INT_1 w0.203: 52.74,48.58 v1(53.73,49.57)
  L6_INT_2 w0.191: v1(38.93,21.24) 39.4,21.24 39.87,20.78 57.34,20.78 57.41,20.71 98.74,20.71 104.96,26.93 104.96,44.25 104.9,44.31 104.9,44.71 104.96,44.77 104.96,45.6 v1(100.42,50.14)
  BOTTOM w0.16: v1(59.45,48.43) 56.39,48.43 55.4,49.43 54.33,49.43 54.19,49.57 v1(53.73,49.57)
PTB29/FTM7_CH1/LPSPI2_SCK/ADC0_: length 152
  TOP w0.16: U7.69 v1(59.45,46.43) ; U8.79 54.28,47.43 54.28,47.43 v1(53.3,47.43)
  TOP w0.406: v1(101.83,50.15) 101.43,50.54 R184.1
  L3_INT_1 w0.191: 52.74,46.87 49.54,43.67 49.54,41.17 49.33,40.97 49.33,37.25 49.72,36.86 49.72,34.02 48.39,32.69 48.39,27.34 46.27,25.21 37.92,25.21 36.82,26.32 36.82,26.89 35.98,27.73 34.08,27.73 J3.8
  L3_INT_1 w0.203: 52.74,46.87 v1(53.3,47.43)
  L6_INT_2 w0.191: v1(101.83,50.15) 101.36,50.61 100.22,50.61 99.94,50.33 99.94,49.94 102.2,47.69 102.27,47.69 103.16,46.8 103.16,41.77 102.65,41.27 102.25,41.27 101.97,41.55 101.97,41.88 101.63,42.22 99.21,42.22 90.28,33.3 90.28,23.76 88.25,21.72 83.59,21.72 83.58,21.72 40.97,21.72 39.17,23.52 39.17,24.53 38.5,25.2 34.41,25.2 J3.8
  BOTTOM w0.16: v1(59.45,46.43) 57.5,46.43 56.5,47.43 v1(53.3,47.43)
PTB30/FTM7_CH2: length 48.7
  TOP w0.16: U8.80 v1(54.65,46.93)
  L3_INT_1 w0.191: v1(51.29,75.25) 51.29,76.4 51.86,76.97 51.86,80.41 52.52,81.07 59.48,81.07 J1.6
  BOTTOM w0.191: v1(54.65,46.93) 53.13,46.93 52.57,47.49 52.57,50.8 52.57,50.8 52.57,51.99 52.57,51.99 52.57,52.12 50.02,54.67 50.02,59.61 49.43,60.2 49.43,66.07 50,66.64 50,73.96 v1(51.29,75.25)
PTB31/FTM7_CH3: length 50.8
  TOP w0.16: U8.82 v1(54.65,45.92)
  L3_INT_1 w0.191: v1(50.45,75.28) 51.04,74.69 58.18,74.69 58.86,74 61.25,74 62.47,75.22 v1(62.47,76.21)
  BOTTOM w0.191: v1(62.47,76.21) 62.47,75.14 R641.2 62.06,74.58 R642.1 ; v1(54.65,45.92) 54.01,45.92 53.35,46.58 52.99,46.58 50.58,48.99 50.58,49.82 49.7,50.7 49.7,59.48 49.12,60.07 49.12,66.2 49.68,66.77 49.68,74.51 v1(50.45,75.28)
PTC0/MII_RMII_RXD1: length 103.4
  TOP w0.406: R277.2 v1(56.92,32.29) ; R63.2 v1(103.61,70.57)
  L6_INT_2 w0.191: v1(103.61,70.57) 104.09,70.09 104.22,70.09 105.27,71.14 105.4,71.14 105.5,71.05 105.5,70.91 104.45,69.86 104.45,69.73 104.54,69.64 104.67,69.64 105.72,70.69 105.85,70.69 105.95,70.6 105.95,70.47 104.89,69.41 104.89,69.28 104.99,69.19 105.12,69.19 106.17,70.24 106.3,70.24 106.39,70.15 106.39,70.02 105.34,68.97 105.34,68.83 105.44,68.74 105.57,68.74 106.62,69.79 106.75,69.79 106.84,69.7 106.84,69.57 105.79,68.52 105.79,68.39 105.89,68.29 106.02,68.29 107.07,69.34 107.2,69.34 107.29,69.25 107.29,69.12 106.24,68.07 106.24,67.94 107.58,66.6 107.58,63.93 107.48,63.84 106.46,63.84 106.36,63.75 106.36,63.62 106.46,63.52 107.48,63.52 107.58,63.43 107.58,63.3 107.48,63.21 106.46,63.21 106.36,63.11 106.36,62.98 106.46,62.89 107.48,62.89 107.58,62.8 107.58,62.66 107.48,62.57 106.46,62.57 106.36,62.48 106.36,62.35 106.46,62.25 107.48,62.25 107.58,62.16 107.58,56.79 102.03,51.25 99.96,51.25 99.31,50.6 99.31,45.73 85.11,31.54 79.52,31.54 79.27,31.79 60.67,31.79 60.59,31.87 57.35,31.87 v1(56.92,32.29)
PTC0/MII_RMII_RXD1/QSPI_B_RWD_1: length 4.2
  TOP w0.229: U16.13 49.18,35.41 48.57,34.81 v1(47.92,34.81) 47.91,34.81 48.09,34.99 48.09,35.65
  BOTTOM w0.229: v1(47.92,34.81) 47.91,34.81 48.09,34.99 48.09,35.65
PTC0/MII_RMII_RXD1/QSPI_B_RWDS: length 43.7
  TOP w0.16: U7.53 v1(59.45,54.43) ; U8.61 v1(54.18,56.43)
  TOP w0.406: R259.1 v1(45.68,35.65)
  L3_INT_1 w0.191: 52.74,55.87 47.85,55.87 45.42,53.43 44.37,53.43 42.04,51.1 42.04,48.71 41.28,47.95 41.28,42.28 41.78,41.79 41.78,41.11 41.15,40.49 41.15,39.43 42.58,38 43.33,38 v1(45.68,35.65)
  L3_INT_1 w0.203: v1(54.18,56.43) 53.61,55.87 52.74,55.87
  BOTTOM w0.16: v1(54.18,56.43) 55.76,56.43 57.76,54.43 v1(59.45,54.43)
PTC0/MII_RMII_RXD1/QSPI_B_RWDS_: length 4.7
  TOP w0.279: v1(54.32,34.61) 54.32,35.21 54.12,35.41 U16.2
  TOP w0.406: R277.1 55.71,33.77 55.17,33.77 54.74,34.2 54.73,34.2 v1(54.32,34.61)
  BOTTOM w0.406: v1(54.32,34.61) 54.3,34.63 R598.2
PTC1/MII_RMII_RXD0: length 104.6
  TOP w0.406: R74.2 v1(103.19,69.56) ; R264.2 56.6,34.1 57.14,33.56 v1(57.21,33.56)
  L6_INT_2 w0.191: v1(57.21,33.56) 57.43,33.78 58.95,33.78 60.23,32.5 60.86,32.5 60.93,32.43 79.53,32.43 79.78,32.17 83.8,32.17 92.42,40.79 92.42,46.16 93.68,47.42 93.68,47.43 98.47,52.23 100.13,52.23 101.96,54.07 101.96,54.19 105.02,57.25 105.02,60.02 105.11,60.12 107.11,60.12 107.2,60.21 107.2,60.34 107.11,60.43 105.11,60.43 105.02,60.53 105.02,60.66 105.11,60.75 107.11,60.75 107.2,60.84 107.2,60.98 107.11,61.07 105.11,61.07 105.02,61.16 105.02,61.29 105.11,61.39 107.11,61.39 107.2,61.48 107.2,61.61 107.11,61.7 105.11,61.7 105.02,61.8 105.02,64.15 104.92,64.24 103.57,64.24 103.47,64.33 103.47,64.47 103.57,64.56 104.92,64.56 105.02,64.65 105.02,64.78 104.92,64.88 103.57,64.88 103.47,64.97 103.47,65.1 103.57,65.19 104.92,65.19 105.02,65.29 105.02,65.42 104.92,65.51 103.57,65.51 103.47,65.6 103.47,65.74 103.57,65.83 104.92,65.83 105.02,65.92 105.02,66.05 104.92,66.15 103.57,66.15 103.47,66.24 103.47,66.37 103.57,66.46 104.92,66.46 105.02,66.56 105.02,66.69 104.92,66.78 103.57,66.78 103.47,66.87 103.47,67.01 103.57,67.1 104.92,67.1 105.02,67.19 105.02,67.73 v1(103.19,69.56)
PTC1/MII_RMII_RXD0/QSPI_B_SCK: length 45.8
  TOP w0.16: U7.52 v1(58.98,54.93) ; U8.60 v1(54.65,56.93)
  TOP w0.406: R253.1 46.57,36.66 v1(46.16,36.26)
  L3_INT_1 w0.191: 52.74,56.93 52.72,56.91 46.96,56.91 39.8,49.75 39.8,48.53 40.5,47.83 40.5,42.61 41.46,41.65 41.46,41.25 40.84,40.63 40.84,39.3 42.45,37.68 42.91,37.68 45.42,35.17 45.88,35.17 46.16,35.46 v1(46.16,36.26)
  L3_INT_1 w0.203: 52.74,56.93 v1(54.65,56.93)
  BOTTOM w0.16: v1(54.65,56.93) 55.76,56.93 57.77,54.93 v1(58.98,54.93)
PTC1/MII_RMII_RXD0/QSPI_B_SCK_1: length 3.3
  TOP w0.229: 48.09,36.66 48.34,36.66 v1(48.93,36.07) 49.09,35.91 U16.12
  BOTTOM w0.229: v1(48.93,36.07) 48.34,36.66 48.09,36.66
PTC1/MII_RMII_RXD0/QSPI_B_SCK__: length 4.4
  TOP w0.279: R264.1 54.78,35.44 v1(54.78,35.67) 54.54,35.91 U16.3
  BOTTOM w0.279: R264.1 55.13,34.63 54.78,34.99 v1(54.78,35.67)
PTC2/MII_RMII_TXD0: length 103.8
  TOP w0.406: v1(102.98,63.82) 103.04,63.82 103.04,63.76 103.49,64.22 R102.2 ; R260.2 57.25,35 57.25,35 v1(57.67,34.59)
  L6_INT_2 w0.191: v1(102.98,63.82) 102.98,62.35 103.67,61.66 103.8,61.66 104.02,61.88 104.16,61.88 104.25,61.79 104.25,61.66 104.03,61.43 104.03,61.3 104.38,60.95 104.38,57.51 101.33,54.46 101.33,54.33 99.87,52.87 99.55,52.87 99.46,52.96 99.46,53.21 99.36,53.31 99.23,53.31 99.14,53.21 99.14,52.96 99.04,52.87 98.21,52.87 93.04,47.7 93.04,47.68 91.78,46.42 91.78,42.03 90.33,40.58 90.2,40.58 90,40.77 89.87,40.77 89.77,40.68 89.77,40.55 89.97,40.35 89.97,40.22 89.88,40.13 89.75,40.13 89.55,40.33 89.42,40.33 89.33,40.23 89.33,40.1 89.52,39.9 89.52,39.77 89.43,39.68 89.3,39.68 89.1,39.88 88.97,39.88 88.88,39.78 88.88,39.65 89.07,39.45 89.07,39.32 88.98,39.23 88.85,39.23 88.65,39.43 88.52,39.43 88.43,39.33 88.43,39.2 88.63,39 88.63,38.87 88.53,38.78 88.4,38.78 88.2,38.98 88.07,38.98 87.98,38.89 87.98,38.75 88.18,38.55 88.18,38.42 88.08,38.33 87.95,38.33 87.75,38.53 87.62,38.53 87.53,38.44 87.53,38.3 87.73,38.11 87.73,37.97 87.63,37.88 87.5,37.88 87.3,38.08 87.17,38.08 87.08,37.99 87.08,37.86 87.28,37.66 87.28,37.53 87.19,37.43 87.05,37.43 86.86,37.63 86.72,37.63 86.63,37.54 86.63,37.41 86.83,37.21 86.83,37.08 86.74,36.98 86.6,36.98 86.41,37.18 86.27,37.18 86.18,37.09 86.18,36.96 86.38,36.76 86.38,36.63 86.29,36.53 86.16,36.53 85.96,36.73 85.83,36.73 85.73,36.64 85.73,36.51 85.93,36.31 85.93,36.18 85.84,36.09 85.71,36.09 85.51,36.28 85.38,36.28 85.28,36.19 85.28,36.06 85.48,35.86 85.48,35.73 85.39,35.64 85.26,35.64 85.06,35.83 84.93,35.83 84.83,35.74 84.83,35.61 85.03,35.41 85.03,35.28 83.85,34.1 83.53,34.1 83.44,34.19 83.44,34.38 83.35,34.48 83.22,34.48 83.12,34.38 83.12,34.19 83.03,34.1 82.9,34.1 82.81,34.19 82.81,34.38 82.71,34.48 82.58,34.48 82.49,34.38 82.49,34.19 82.39,34.1 82.26,34.1 82.17,34.19 82.17,34.38 82.08,34.48 81.95,34.48 81.85,34.38 81.85,34.19 81.76,34.1 81.63,34.1 81.54,34.19 81.54,34.38 81.44,34.48 81.31,34.48 81.22,34.38 81.22,34.19 81.12,34.1 80.56,34.1 79.53,33.06 78.37,33.06 78.27,33.16 78.27,33.81 78.18,33.9 78.05,33.9 77.95,33.81 77.95,33.16 77.86,33.06 77.73,33.06 77.64,33.16 77.64,33.81 77.54,33.9 77.41,33.9 77.32,33.81 77.32,33.16 77.23,33.06 77.1,33.06 77,33.16 77,33.81 76.91,33.9 76.78,33.9 76.68,33.81 76.68,33.16 76.59,33.06 76.46,33.06 76.37,33.16 76.37,33.81 76.27,33.9 76.14,33.9 76.05,33.81 76.05,33.16 75.96,33.06 75.83,33.06 75.73,33.16 75.73,33.81 75.64,33.9 75.51,33.9 75.41,33.81 75.41,33.16 75.32,33.06 75.19,33.06 75.1,33.16 75.1,33.81 75,33.9 74.87,33.9 74.78,33.81 74.78,33.16 74.69,33.06 74.56,33.06 74.46,33.16 74.46,33.81 74.37,33.9 74.24,33.9 74.14,33.81 74.14,33.16 74.05,33.06 73.92,33.06 73.83,33.16 73.83,33.81 73.73,33.9 73.6,33.9 73.51,33.81 73.51,33.16 73.42,33.06 73.29,33.06 73.19,33.16 73.19,33.81 73.1,33.9 72.97,33.9 72.87,33.81 72.87,33.16 72.78,33.06 72.65,33.06 72.56,33.16 72.56,33.81 72.46,33.9 72.33,33.9 72.24,33.81 72.24,33.16 72.15,33.06 72.02,33.06 71.92,33.16 71.92,33.81 71.83,33.9 71.7,33.9 71.6,33.81 71.6,33.16 71.51,33.06 71.38,33.06 71.29,33.16 71.29,33.81 71.19,33.9 71.06,33.9 70.97,33.81 70.97,33.16 70.88,33.06 69.34,33.06 69.25,33.16 69.25,33.33 69.16,33.42 69.02,33.42 68.93,33.33 68.93,33.16 68.84,33.06 68.71,33.06 68.61,33.16 68.61,33.33 68.52,33.42 68.39,33.42 68.3,33.33 68.3,33.16 68.2,33.06 68.07,33.06 67.98,33.16 67.98,33.33 67.89,33.42 67.75,33.42 67.66,33.33 67.66,33.16 67.57,33.06 62.78,33.06 62.69,33.16 62.69,33.68 62.59,33.77 62.46,33.77 62.37,33.68 62.37,33.16 62.28,33.06 62.15,33.06 62.05,33.16 62.05,33.68 61.96,33.77 61.83,33.77 61.74,33.68 61.74,33.16 61.64,33.06 61.2,33.06 61.12,33.14 60.7,33.14 59.25,34.59 v1(57.67,34.59)
PTC2/MII_RMII_TXD0/QSPI_A_IO3: length 54.1
  TOP w0.16: v1(53.53,61.22) 53.99,61.22 54.2,61.44 U8.51 ; U7.43 v1(59.45,59.43)
  TOP w0.406: R249.1 46.01,37.68 v1(45.91,37.77)
  L3_INT_1 w0.191: v1(51.32,57.95) 50.6,57.23 46.65,57.23 42.31,52.89 41.12,52.89 39.94,51.71 39.94,51.04 39.48,50.58 39.48,48.4 39.65,48.23 39.65,42.46 40.49,41.61 40.49,39.19 42.32,37.37 42.78,37.37 45.29,34.85 46.01,34.85 46.64,35.48 46.64,36.47 45.91,37.2 v1(45.91,37.77)
  L6_INT_2 w0.191: v1(51.32,57.95) 52.74,59.37
  L6_INT_2 w0.203: v1(53.53,61.22) 53.53,60.16 52.74,59.37
  BOTTOM w0.16: v1(59.45,59.43) 57.33,59.43 55.36,61.4 54.16,61.4 53.99,61.22 v1(53.53,61.22)
PTC2/MII_RMII_TXD0/QSPI_A_IO3_1: length 3.6
  TOP w0.229: U16.11 49.44,36.41 48.86,36.99 v1(48.86,37.68) 48.09,37.68
  BOTTOM w0.229: v1(48.86,37.68) 48.09,37.68
PTC2/MII_RMII_TXD0/QSPI_A_IO3__: length 4.6
  TOP w0.279: R260.1 R254.1 v1(54.67,36.66) 54.42,36.41 U16.4
  BOTTOM w0.279: v1(54.67,36.66) 55.17,36.16 55.17,36.06 R260.1
PTC2/QSPI_A_IO3: length 48.4
  TOP w0.406: R254.2 56.86,36.41 57.49,36.41 v1(57.65,36.26)
  L6_INT_2 w0.191: v1(37.48,35.37) 38.16,34.69 41.01,34.69 41.18,34.85 46.72,34.85 47.22,35.36 48.51,35.36 48.59,35.28 52.4,35.28 53.31,36.19 54.87,36.19 54.94,36.26 v1(57.65,36.26)
  BOTTOM w0.406: R586.1 22.44,36.54 22.17,36.54 21.65,36.01 21.02,36.01 20.87,35.86 20.87,35.63 21.02,35.48 21.65,35.48 21.81,35.32 21.81,33.94 22.67,33.08 30.19,33.08 31.18,32.09 32.72,32.09 33.17,31.63 36.92,31.63 37.48,32.19 v1(37.48,35.37)
PTC3/MII_TX_ER: length 119.7
  TOP w0.406: v1(42.08,42.96) 40.53,42.96 40.4,43.09 40.4,43.09 R212.2 ; R55.1 v1(121.25,72.86)
  L6_INT_2 w0.191: v1(42.08,42.96) 42.08,42.49 43.41,41.15 45.15,41.15 45.64,41.63 45.64,41.71 46.12,42.19 49.12,42.19 50.87,40.44 55.99,40.44 56.57,41.03 84.08,41.03 84.1,41.05 85.01,41.05 88.25,44.29 88.25,51.21 88.44,51.4 93.74,56.7 96.16,56.7 96.63,57.16 96.63,57.17 99.3,59.85 99.3,64.78 98.72,65.36 98.72,66.13 95.04,69.8 95.04,71.54 98.23,74.72 99.27,74.72 101.77,77.23 116.4,77.23 120.77,72.86 v1(121.25,72.86)
PTC3/MII_TX_ER/QSPI_A_CS/QSPI_1: length 3.5
  TOP w0.279: R175.2 38.82,51.78 v1(38.82,51.5) 38.57,51.24 U11.11
  BOTTOM w0.279: R175.2 38.82,51.78 v1(38.82,51.5)
PTC3/MII_TX_ER/QSPI_A_CS/QSPI_2: length 29
  TOP w0.16: U8.50 v1(54.65,61.94) ; U7.42 v1(58.98,59.93)
  TOP w0.406: R175.1 v1(38.19,55.61)
  L3_INT_1 w0.191: 52.74,61.94 44.04,61.94 38.19,56.09 v1(38.19,55.61)
  L3_INT_1 w0.203: 52.74,61.94 v1(54.65,61.94)
  BOTTOM w0.16: v1(58.98,59.93) 57.47,59.93 55.46,61.94 v1(54.65,61.94)
PTC3/MII_TX_ER/QSPI_A_CS/QSPI_B: length 4.9
  TOP w0.279: R213.1 R212.1 38.85,45.65 v1(38.85,46.04) 38.57,46.32 U11.4
  BOTTOM w0.279: v1(38.85,46.04) 39.61,46.04 R213.1
PTC3/QSPI_A_CS: length 48.5
  TOP w0.406: v1(42.48,43.55) 42.22,43.55 41.08,43.55 R213.2
  L6_INT_2 w0.191: v1(37.73,38.75) 37.73,39.22 37.5,39.45 37.5,40.4 37.6,40.49 37.94,40.49 38.03,40.4 38.03,39.98 38.12,39.89 38.25,39.89 38.35,39.98 38.35,40.4 38.44,40.49 38.57,40.49 38.66,40.4 38.66,39.98 38.76,39.89 38.89,39.89 38.98,39.98 38.98,40.4 39.07,40.49 41.27,40.49 41.36,40.58 41.36,40.71 41.27,40.81 37.6,40.81 37.5,40.9 37.5,41.58 37.81,41.9 40.25,41.9 40.47,42.12 40.47,42.25 40.14,42.59 40,42.59 39.76,42.34 39.63,42.34 39.54,42.44 39.54,42.57 39.78,42.81 39.78,42.94 39.69,43.04 39.56,43.04 39.31,42.79 39.18,42.79 39.09,42.89 39.09,43.02 39.33,43.26 39.33,43.39 39.24,43.48 39.11,43.48 38.86,43.24 38.73,43.24 38.64,43.34 38.64,43.47 38.88,43.71 38.88,43.84 38.66,44.07 38.66,44.2 38.75,44.29 38.88,44.29 40.7,42.48 40.83,42.48 40.92,42.57 40.92,42.7 39.1,44.52 39.1,44.65 39.2,44.74 39.33,44.74 41.14,42.92 41.28,42.92 41.37,43.02 41.37,43.15 39.55,44.97 39.55,45.1 39.65,45.19 39.78,45.19 40.3,44.67 40.43,44.67 40.66,44.89 40.66,45.02 40.16,45.52 40.16,45.65 40.26,45.74 40.39,45.74 40.88,45.25 41.01,45.25 41.61,45.85 41.74,45.85 41.83,45.75 41.83,45.62 40.66,44.44 40.66,44.31 40.75,44.22 40.88,44.22 42.06,45.4 42.19,45.4 42.28,45.3 42.28,45.17 41.1,43.99 41.1,43.86 41.59,43.37 41.73,43.37 41.9,43.55 v1(42.48,43.55)
  BOTTOM w0.406: R581.1 37.55,38.82 37.58,38.8 37.73,38.8 v1(37.73,38.75)
PTC4/FTM1_CH0/RTC_CLKOUT/JTAG_T: length 174.1
  TOP w0.16: U8.169 v1(82.92,60.94) ; U7.140 v1(77.63,60.43)
  TOP w0.406: R298.2 35.42,15.62 36.5,16.7 38.01,16.7 38.42,16.29 v1(38.42,15.1)
  L3_INT_1 w0.191: 83.93,60.94 95.08,60.94 96.92,62.78 97.09,62.78 97.36,63.06 97.36,63.52 96.46,64.42 96.46,67.23 97.5,68.26 v1(97.5,69)
  L3_INT_1 w0.203: v1(82.92,60.94) 83.93,60.94
  L6_INT_2 w0.191: v1(97.5,69) 97.5,69.82 97.54,69.87 97.54,70.59 100.65,73.7 103.74,73.7 108.21,69.23 108.21,55.16 106.62,53.57 106.62,22.27 97.82,13.48 47.38,13.48 45.76,15.1 v1(38.42,15.1)
  BOTTOM w0.16: v1(82.92,60.94) 79.73,60.94 79.23,60.43 v1(77.63,60.43)
  BOTTOM w0.406: R510.2 96.91,68.41 v1(97.5,69)
PTC5/FTM2_CH0/RTC_CLKOUT/JTAG_T: length 26.9
  TOP w0.16: U7.139 v1(78.1,59.93) ; U8.168 v1(82.44,60.44)
  L3_INT_1 w0.191: 83.93,60.44 95.03,60.44 97.05,62.46 97.22,62.46 97.68,62.93 97.68,63.91 v1(96.94,64.65)
  L3_INT_1 w0.203: 83.93,60.44 v1(82.44,60.44)
  BOTTOM w0.16: v1(82.44,60.44) 81.93,59.93 v1(78.1,59.93)
  BOTTOM w0.406: R516.2 96.13,63.84 v1(96.94,64.65)
PTC6/LPUART1_RX/CAN1_RX/FTM3_CH: length 139.9
  TOP w0.16: U7.118 v1(77.63,49.43) ; v1(82.87,48.43) U8.144
  L3_INT_1 w0.191: 80.72,38.62 79.39,37.29 79.39,34.98 78.74,34.32 78.06,34.32 v1(74.66,30.92)
  L3_INT_1 w0.203: 80.72,38.62 80.93,38.83 80.93,40.33 79.34,41.92 79.34,48.38 78.28,49.43 v1(77.63,49.43)
  BOTTOM w0.16: v1(82.87,48.43) 81.16,48.43 80.16,49.43 v1(77.63,49.43)
  BOTTOM w0.203: v1(82.87,48.43) 83.45,48.43 84.42,49.39 84.42,50.58 85.28,51.45 85.28,53.24 88.53,56.49 88.53,56.54 88.84,56.84 88.84,57.11 88.84,57.12 88.84,57.94 88.84,57.94 88.84,66.98 89.09,67.23 89.09,67.5 89.09,67.5 89.09,68.32 89.09,68.33 89.09,73.38 87.4,75.07 87.1,75.07 85,77.17 85,78 83.78,79.22 J6.11
  BOTTOM w0.406: v1(74.66,30.92) 74.92,30.67 74.92,25.13 71.56,21.78 57.54,21.78 56.32,20.56 56.32,15.92 50.42,10.02 33.57,10.02 32.75,10.83 29.02,10.83 28.13,9.94 23.43,9.94 v1(21.65,11.72) 21.5,11.87 R627.2
PTC7/LPUART1_TX/CAN1_TX/FTM3_CH: length 135.8
  TOP w0.16: U8.143 82.41,47.93 v1(82.44,47.9) ; U7.117 v1(78.1,48.93)
  L3_INT_1 w0.191: v1(22.44,16.65) 23.62,15.47 23.62,12.56 25.66,10.52 27.84,10.52 28.05,10.73 42.81,10.73 48.3,16.22 55.23,16.22 58.81,19.8 66.73,19.8 72.17,25.24 72.17,29.76 77.38,34.97 78.47,34.97 78.75,35.25 78.75,37.87 79.5,38.62
  L3_INT_1 w0.203: v1(78.1,48.93) 77.45,48.93 76.44,47.93 76.44,46.09 76.72,45.81 77.54,45.81 77.9,45.45 78.26,45.45 78.6,45.11 78.6,41.65 80.22,40.03 80.22,39.34 79.5,38.62
  BOTTOM w0.16: v1(82.44,47.9) 81.06,47.9 80.02,48.93 v1(78.1,48.93)
  BOTTOM w0.203: v1(82.44,47.9) 83.42,47.9 84.95,49.42 84.95,50.33 85.81,51.19 85.81,53.31 88.86,56.36 88.86,56.4 89.17,56.7 89.17,56.98 89.17,58.07 89.17,58.07 89.17,66.84 89.42,67.09 89.42,67.37 89.42,68.46 89.42,68.46 89.42,73.52 88.86,74.08 88.86,74.94 87.64,76.15 87.64,78.65 J6.8
  BOTTOM w0.279: v1(22.44,16.65) 22.95,16.14 22.95,16.01
PTC8/LPUART1_RX: length 156.1
  TOP w0.16: U7.81 v1(63.79,44.12) ; 63.29,40.98 v1(63.29,39.32)
  TOP w0.305: v1(19.93,9.73) 19.93,11.2 20.36,11.63 R305.2
  TOP w0.406: R34.1 61.79,75.49 61.73,75.45 61.73,75.47 v1(61.67,75.47)
  L3_INT_1 w0.191: v1(39.69,12.46) 40.55,13.32 40.55,17.77 45.37,22.58 47.46,22.58 48.25,23.37 48.25,23.71 49.66,25.12 49.66,27.08 50.35,27.77 53.46,27.77 54.6,28.91 54.6,29.48 55.39,30.27 59.37,30.27 62.15,33.06 62.15,37.99 62.79,38.62
  L3_INT_1 w0.203: v1(63.29,39.32) 63.29,39.12 62.79,38.62
  L6_INT_2 w0.191: v1(39.69,12.46) 39.69,11.69 37.72,9.73 v1(19.93,9.73)
  L6_INT_2 w0.203: v1(83.63,73.19) 82.56,74.25 82.56,80.21 81.7,81.07 75.34,81.07 75.02,81.39 67.88,81.39 67.07,80.58 67.07,79.06 63.48,75.47 v1(61.67,75.47)
  BOTTOM w0.16: v1(63.29,39.32) 63.29,40.4 63.79,40.9 v1(63.79,44.12)
  BOTTOM w0.203: v1(63.79,44.12) 63.79,44.78 64.24,45.22 65.23,45.22 69.91,49.9 76.88,49.9 77.75,50.77 79.6,50.77 81.72,52.89 82.78,52.89 87.52,57.63 87.52,67.52 87.54,67.55 87.54,72.91 86.92,73.53 83.97,73.53 v1(83.63,73.19)
PTC9/LPUART1_TX: length 141.8
  TOP w0.16: U7.80 v1(63.29,44.59) ; 62.79,40.98 v1(62.79,39.79)
  TOP w0.406: R14.1 v1(59.91,76.25)
  L3_INT_1 w0.191: v1(57.16,30.74) 59.17,30.74 61.84,33.41 61.84,38.17 62.28,38.62
  L3_INT_1 w0.203: v1(62.79,39.79) 62.79,39.12 62.28,38.62
  L6_INT_2 w0.191: v1(79.32,64.67) 79.32,62.48 78.3,61.45 77.79,61.45 77.33,61.91 76.72,61.91 76.37,61.55 75.85,61.55 73.4,59.11 73.4,55.79 74.02,55.17 77.15,55.17 78.52,53.8 78.52,51.03 76.72,49.24 67.93,49.24 v1(63.29,44.59) ; v1(77.41,74.51) 77.41,74.99 76.08,76.31 75.73,76.31 74.97,77.07 74.97,77.64 73.76,78.85 67.65,78.85 63.49,74.69 61.47,74.69 v1(59.91,76.25) ; v1(49.42,18.45) 48.98,18.88 46.49,18.88 45.3,17.69 34.57,17.69 33.89,18.37 30.13,18.37 29.35,17.59 27.11,17.59 26.09,16.56 v1(24.57,16.56)
  BOTTOM w0.16: v1(63.29,44.59) 63.29,40.85 62.98,40.53 62.98,39.97 v1(62.79,39.79)
  BOTTOM w0.203: v1(79.32,64.67) 82.08,67.42 82.08,69.05
  BOTTOM w0.406: v1(57.16,30.74) 57.16,23.18 55.46,21.47 50.94,21.47 49.83,20.36 49.83,18.86 v1(49.42,18.45) ; v1(24.57,16.56) 24.43,16.56 R619.2 ; v1(77.41,74.51) 82.08,69.84 82.08,69.05
PTC10/FTM3_CH4/TRGMUX_IN11: length 55.5
  TOP w0.16: 60.29,40.98 v1(60.29,39.32) ; U7.75 v1(60.79,44.12)
  L6_INT_2 w0.203: v1(60.79,44.12) 60.31,43.64 55.98,43.64 55.21,44.41 53.73,44.41 53.27,43.94 52.57,43.94 47.89,48.62 47.89,55.59 52.74,60.44 v1(52.74,60.92)
  BOTTOM w0.16: v1(60.79,44.12) 60.79,41.1 60.29,40.6 v1(60.29,39.32)
  BOTTOM w0.203: v1(52.74,60.92) 52.74,67.96 53.84,69.05
  BOTTOM w0.406: J1.10 53.84,75.42 53.84,69.05
PTC11/FTM3_CH5/FTM4_CH2/TRGMUX_: length 59.1
  TOP w0.16: 59.28,40.98 v1(59.28,39.32) ; U7.74 v1(60.29,44.59)
  TOP w0.406: v1(48.3,74.53) 49.54,75.78 49.54,77.92 50.27,78.65 57.16,78.65 J1.7
  L3_INT_1 w0.191: 54.19,69.05 49.04,74.2 48.64,74.2 v1(48.3,74.53)
  L3_INT_1 w0.203: v1(60.29,44.59) 60.28,44.61 59.59,44.61 59.43,44.45 58.78,44.45 58.5,44.73 58.5,65.24 55.92,67.83 55.41,67.83 54.19,69.05
  BOTTOM w0.16: v1(60.29,44.59) 60.29,41.75 59.28,40.74 v1(59.28,39.32)
PTC12: length 10.7
  TOP w0.16: U7.71 v1(59.52,45.43) ; U8.84 v1(54.65,44.92)
  BOTTOM w0.16: v1(54.65,44.92) 55.15,45.43 v1(59.52,45.43)
  BOTTOM w0.203: v1(59.52,45.43) 59.73,45.43 60.36,46.06 R567.2 R565.2
PTC12/BTN0: length 96.3
  TOP w0.406: R306.2 C109.1 v1(93.66,14.13)
  L3_INT_1 w0.191: v1(51.96,45.3) 50.32,43.66 50.32,34.14 48.71,32.53 48.71,26.99 47.13,25.41 v1(47.13,23.38)
  L6_INT_2 w0.191: v1(51.96,45.3) 54.11,47.45 59.18,47.45 59.63,47.91 62.83,47.91 v1(63.94,46.8) ; v1(47.13,18.07) 47.13,17.16 50.48,13.8 92.86,13.8 93.19,14.13 v1(93.66,14.13)
  BOTTOM w0.203: R565.1 62.88,47.03 TP507.1 63.89,46.75 v1(63.94,46.8)
  BOTTOM w0.406: v1(47.13,23.38) v1(47.13,18.07)
PTC12/FTM3_CH6/FTM2_CH6/LPUART2: length 53.2
  L3_INT_1 w0.191: J6.5 87.75,78.86 87.75,73.91 v1(86.8,72.96)
  BOTTOM w0.203: R567.1 65.06,46.06 69.92,50.91 77.39,50.91 77.6,51.12 78.94,51.12 81.9,54.09 83.47,54.09 87.19,57.8 87.19,67.66 87.21,67.69 87.21,72.55 v1(86.8,72.96)
PTC13: length 12.1
  TOP w0.16: U7.70 v1(58.98,45.93) ; U8.81 v1(54.18,46.43)
  BOTTOM w0.16: v1(58.98,45.93) 55.59,45.93 55.1,46.43 v1(54.18,46.43)
  BOTTOM w0.203: v1(58.98,45.93) 59.64,45.93 60.44,46.73 60.44,47.38 R562.2 R561.2
PTC13/BTN1: length 78.9
  TOP w0.406: R307.2 C110.1 v1(97.62,13.96)
  L3_INT_1 w0.191: v1(84.67,30.72) 87.7,33.75 87.7,43.95 87.69,43.96 87.69,53.11 85.57,55.24 85.25,55.24 v1(84.59,55.89)
  BOTTOM w0.203: R562.1 63.13,47.99 TP506.1 66.59,51.39 76.88,51.39 77.84,52.36 79.34,52.36 82.21,55.24 83.93,55.24
  BOTTOM w0.406: v1(84.67,30.72) 85.1,30.29 85.1,25.03 96.18,13.96 v1(97.62,13.96) ; v1(84.59,55.89) 83.93,55.24
PTC13/FTM3_CH7/FTM2_CH7/LPUART2: length 52
  L3_INT_1 w0.191: v1(86.73,69.89) 92.51,75.67 92.51,78.86 J6.2
  BOTTOM w0.191: R561.1 63.56,48.96 66.38,51.78 76.76,51.78 77.7,52.71 78.2,52.71 81.33,55.84 82.54,55.84 83.11,56.41
  BOTTOM w0.203: 83.11,56.41 83.93,57.24
  BOTTOM w0.406: v1(86.73,69.89) 86.73,60.03 83.93,57.24
PTC14/FTM1_CH2/LPSPI2_PCS0/ADC0: length 55.4
  TOP w0.16: U7.61 v1(60.69,50.43) ; U8.70 v1(54.65,51.93)
  TOP w0.406: v1(78.27,35.44) 79.71,35.44 83.19,31.96 87.31,31.96 88.86,30.41 J5.13
  L3_INT_1 w0.191: v1(78.27,35.44) 78.27,37.89 79,38.62
  L3_INT_1 w0.203: v1(60.69,50.43) 60.69,49.37 64.3,45.76 76.01,45.76 77.05,44.71 77.6,44.71 78.19,44.12 78.19,41.55 79.86,39.88 79.86,39.48 79,38.62
  BOTTOM w0.16: v1(60.69,50.43) 57.06,50.43 55.56,51.93 v1(54.65,51.93)
PTC15/FTM1_CH3/LPSPI2_SCK/QSPI_: length 75.7
  TOP w0.16: U8.67 v1(54.18,53.43) ; U7.59 v1(59.45,51.43)
  L3_INT_1 w0.191: v1(46.89,28.74) 46.89,33.01 48.4,34.51 48.4,35.01 47.66,35.75 47.66,36.8 47.05,37.4 47.05,38.97 46.6,39.42 46.6,40.75 46.7,40.85 46.7,44.05 47.89,45.25 47.89,50.61 50.71,53.43 52.74,53.43
  L3_INT_1 w0.203: v1(54.18,53.43) 52.74,53.43
  L6_INT_2 w0.191: v1(46.89,28.74) 46.89,28.26 46.8,28.17 46.8,26.5 50.31,22.99 53.76,22.99 54.41,23.65 54.41,24.66 55.26,25.51 58.52,25.51 59.81,24.21 59.81,23.65 60.47,22.99 69.98,22.99 J5.2
  BOTTOM w0.16: v1(59.45,51.43) 57.46,51.43 55.46,53.43 v1(54.18,53.43)
PTC16/MII_RMII_RX_ER: length 157.6
  TOP w0.406: R195.2 42.18,49.52 v1(41.47,48.8) ; R61.1 v1(121.22,71.84)
  L6_INT_2 w0.191: v1(121.22,71.84) 116.15,76.92 101.96,76.92 99.45,74.41 98.36,74.41 95.36,71.41 95.36,69.94 98.44,66.86 101.65,66.86 102.17,66.35 102.17,65.76 101.87,65.47 101.87,61.14 103.11,59.9 103.11,58.04 100.06,54.98 100.06,54.85 99.78,54.58 98.12,54.58 91.77,48.22 91.77,48.21 90.48,46.91 90.48,43.37 85.47,38.36 83.65,38.36 82.6,37.31 76.33,37.31 74.32,35.3 66.19,35.3 65.3,34.41 61.7,34.41 60.73,35.38 55.83,35.38 54.58,34.13 49.43,34.13 48.88,33.58 47.05,33.58 46.53,34.1 41.33,34.1 41.15,33.93 36.4,33.93 35.09,35.24 32.18,35.24 30.09,37.33 30.09,40.97 34.01,44.89 38.38,44.89 41.47,47.98 v1(41.47,48.8)
