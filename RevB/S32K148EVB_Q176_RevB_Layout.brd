# Allegro board S32K148EVB_Q176_RevB_Layout.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
CON_HDR_4M_100_TH_RA
  rect 1.651x1.651 hole 1.016: 1(0,0)
  round 1.651 hole 1.016: 2(2.54,0) 3(5.08,0) 4(7.62,0)
CON_MICROAB_10F_25_SM_RA
  rect 1.372x0.406 smd: 1(2.575,-1.3) 2(2.575,-0.65) 3(2.575,0) 4(2.575,0.65) 5(2.575,1.3)
  oval 1.27x1.067 hole 0.864x0.66: 6(2.9,2.225) 7(2.9,-2.225)
  rect 1.905x2.921 smd: 8(-0.1,0)
  custom 0.356x0.356 hole 1.524x0.838: 9(-0.1,4.09) 10(-0.1,-4.09)
ELECTRODE_SQ_15MM
  rect 15.011x15.011 hole 0.381: 1(-6.35,6.349)
HDR1X2_5P48X2P69
  rect 1.753x1.753 hole 1.118: 1(0,0)
  round 1.753 hole 1.118: 2(2.54,0)
HDR2X2_50MIL
  rect 1.092x1.092 hole 0.711: 1(0,0)
  round 1.092 hole 0.711: 2(1.27,0) 3(0,-1.27) 4(1.27,-1.27)
HDR2X4_50MIL
  rect 1.092x1.092 hole 0.711: 1(0,0)
  round 1.092 hole 0.711: 2(1.27,0) 3(0,-1.27) 4(1.27,-1.27) 5(0,-2.54) 6(1.27,-2.54) 7(0,-3.81) 8(1.27,-3.81)
HDR101_045T
  rect 1.778x1.778 hole 1.143: 1(0,0)
HDR102
  rect 1.524x1.524 hole 1.016: 1(0,0)
  round 1.524 hole 1.016: 2(0,-2.54)
HDR103
  rect 1.524x1.524 hole 1.016: 1(0,0)
  round 1.524 hole 1.016: 2(0,-2.54) 3(0,-5.08)
HDR210_ESQ_SKT
  rect 1.676x1.676 hole 1.016: 1(0,0)
  round 1.676 hole 1.016: 2(-2.54,0) 3(0,-2.54) 4(-2.54,-2.54) 5(0,-5.08) 6(-2.54,-5.08) 7(0,-7.62) 8(-2.54,-7.62) 9(0,-10.16) 10(-2.54,-10.16) 11(0,-12.7) 12(-2.54,-12.7) 13(0,-15.24) 14(-2.54,-15.24) 15(0,-17.78) 16(-2.54,-17.78) 17(0,-20.32) 18(-2.54,-20.32) 19(0,-22.86) 20(-2.54,-22.86)
HDR210_FTSH_SM
  rect 2.794x0.737 smd: 1(-2.032,5.715) 2(2.032,5.715) 3(-2.032,4.445) 4(2.032,4.445) 5(-2.032,3.175) 6(2.032,3.175) 7(-2.032,1.905) 8(2.032,1.905) 9(-2.032,0.635) 10(2.032,0.635) 11(-2.032,-0.635) 12(2.032,-0.635) 13(-2.032,-1.905) 14(2.032,-1.905) 15(-2.032,-3.175) 16(2.032,-3.175) 17(-2.032,-4.445) 18(2.032,-4.445) 19(-2.032,-5.715) 20(2.032,-5.715)
HDR225
  rect 1.981x1.981 hole 1.194: 1(0,0)
  round 1.981 hole 1.194: 2(2.54,0) 3(0,-2.54) 4(2.54,-2.54) 5(0,-5.08) 6(2.54,-5.08) 7(0,-7.62) 8(2.54,-7.62) 9(0,-10.16) 10(2.54,-10.16) 11(0,-12.7) 12(2.54,-12.7) 13(0,-15.24) 14(2.54,-15.24) 15(0,-17.78) 16(2.54,-17.78) 17(0,-20.32) 18(2.54,-20.32) 19(0,-22.86) 20(2.54,-22.86) 21(0,-25.4) 22(2.54,-25.4) 23(0,-27.94) 24(2.54,-27.94) 25(0,-30.48) 26(2.54,-30.48) 27(0,-33.02) 28(2.54,-33.02) 29(0,-35.56) 30(2.54,-35.56) 31(0,-38.1) 32(2.54,-38.1) 33(0,-40.64) 34(2.54,-40.64) 35(0,-43.18) 36(2.54,-43.18) 37(0,-45.72) 38(2.54,-45.72) 39(0,-48.26) 40(2.54,-48.26) 41(0,-50.8) 42(2.54,-50.8) 43(0,-53.34) 44(2.54,-53.34) 45(0,-55.88) 46(2.54,-55.88) 47(0,-58.42) 48(2.54,-58.42) 49(0,-60.96) 50(2.54,-60.96)
HTQFP48_0P65_10X10_EP_5MM
  rect 1.5x0.35 smd: 1(-5.7,3.575) 2(-5.7,2.925) 3(-5.7,2.275) 4(-5.7,1.625) 5(-5.7,0.975) 6(-5.7,0.325) 7(-5.7,-0.325) 8(-5.7,-0.975) 9(-5.7,-1.625) 10(-5.7,-2.275) 11(-5.7,-2.925) 12(-5.7,-3.575) 25(5.7,-3.575) 26(5.7,-2.925) 27(5.7,-2.275) 28(5.7,-1.625) 29(5.7,-0.975) 30(5.7,-0.325) 31(5.7,0.325) 32(5.7,0.975) 33(5.7,1.625) 34(5.7,2.275) 35(5.7,2.925) 36(5.7,3.575)
  rect 0.35x1.5 smd: 13(-3.575,-5.7) 14(-2.925,-5.7) 15(-2.275,-5.7) 16(-1.625,-5.7) 17(-0.975,-5.7) 18(-0.325,-5.7) 19(0.325,-5.7) 20(0.975,-5.7) 21(1.625,-5.7) 22(2.275,-5.7) 23(2.925,-5.7) 24(3.575,-5.7) 37(3.575,5.7) 38(2.925,5.7) 39(2.275,5.7) 40(1.625,5.7) 41(0.975,5.7) 42(0.325,5.7) 43(-0.325,5.7) 44(-0.975,5.7) 45(-1.625,5.7) 46(-2.275,5.7) 47(-2.925,5.7) 48(-3.575,5.7)
  rect 5.004x5.004 smd: 49(0,0)
IND2_6P5X6P2MM_SM
  rect 2.464x2.21 smd: 1(-2.425,0) 2(2.425,0)
IND_5P2X5P2
  rect 2.007x4.191 smd: 1(-1.903,0) 2(1.903,0)
IND_0402
  round 0.635 smd: 1(-0.508,0) 2(0.508,0)
IND_0603
  rect 0.991x0.813 smd: 1(-0.69,0) 2(0.69,0)
IND_1608
  rect 0.61x0.813 smd: 1(-0.7,0) 2(0.7,0)
LED2_2P1X1P5_NSP
  rect 0.787x0.991 smd: A(1,0) C(-1,0)
LED6_5X6MM
  rect 2.007x1.6 smd: A1(-2.25,2.1) A2(-2.25,0) A3(-2.25,-2.1) C1(2.25,2.1) C2(2.25,0) C3(2.25,-2.1)
LED_0603
  rect 0.838x0.787 smd: A(-0.775,0) C(0.775,0)
LQFP144_0P5_20X20MM
  rect 1.422x0.279 smd: 1(-10.7,8.75) 2(-10.7,8.25) 3(-10.7,7.75) 4(-10.7,7.25) 5(-10.7,6.75) 6(-10.7,6.25) 7(-10.7,5.75) 8(-10.7,5.25) 9(-10.7,4.75) 10(-10.7,4.25) 11(-10.7,3.75) 12(-10.7,3.25) 13(-10.7,2.75) 14(-10.7,2.25) 15(-10.7,1.75) 16(-10.7,1.25) 17(-10.7,0.75) 18(-10.7,0.25) 19(-10.7,-0.25) 20(-10.7,-0.75) 21(-10.7,-1.25) 22(-10.7,-1.75) 23(-10.7,-2.25) 24(-10.7,-2.75) 25(-10.7,-3.25) 26(-10.7,-3.75) 27(-10.7,-4.25) 28(-10.7,-4.75) 29(-10.7,-5.25) 30(-10.7,-5.75) 31(-10.7,-6.25) 32(-10.7,-6.75) 33(-10.7,-7.25) 34(-10.7,-7.75) 35(-10.7,-8.25) 36(-10.7,-8.75) 73(10.7,-8.75) 74(10.7,-8.25) 75(10.7,-7.75) 76(10.7,-7.25) 77(10.7,-6.75) 78(10.7,-6.25) 79(10.7,-5.75) 80(10.7,-5.25) 81(10.7,-4.75) 82(10.7,-4.25) 83(10.7,-3.75) 84(10.7,-3.25) 85(10.7,-2.75) 86(10.7,-2.25) 87(10.7,-1.75) 88(10.7,-1.25) 89(10.7,-0.75) 90(10.7,-0.25) 91(10.7,0.25) 92(10.7,0.75) 93(10.7,1.25) 94(10.7,1.75) 95(10.7,2.25) 96(10.7,2.75) 97(10.7,3.25) 98(10.7,3.75) 99(10.7,4.25) 100(10.7,4.75) 101(10.7,5.25) 102(10.7,5.75) 103(10.7,6.25) 104(10.7,6.75) 105(10.7,7.25) 106(10.7,7.75) 107(10.7,8.25) 108(10.7,8.75)
  rect 0.279x1.422 smd: 37(-8.75,-10.7) 38(-8.25,-10.7) 39(-7.75,-10.7) 40(-7.25,-10.7) 41(-6.75,-10.7) 42(-6.25,-10.7) 43(-5.75,-10.7) 44(-5.25,-10.7) 45(-4.75,-10.7) 46(-4.25,-10.7) 47(-3.75,-10.7) 48(-3.25,-10.7) 49(-2.75,-10.7) 50(-2.25,-10.7) 51(-1.75,-10.7) 52(-1.25,-10.7) 53(-0.75,-10.7) 54(-0.25,-10.7) 55(0.25,-10.7) 56(0.75,-10.7) 57(1.25,-10.7) 58(1.75,-10.7) 59(2.25,-10.7) 60(2.75,-10.7) 61(3.25,-10.7) 62(3.75,-10.7) 63(4.25,-10.7) 64(4.75,-10.7) 65(5.25,-10.7) 66(5.75,-10.7) 67(6.25,-10.7) 68(6.75,-10.7) 69(7.25,-10.7) 70(7.75,-10.7) 71(8.25,-10.7) 72(8.75,-10.7) 109(8.75,10.7) 110(8.25,10.7) 111(7.75,10.7) 112(7.25,10.7) 113(6.75,10.7) 114(6.25,10.7) 115(5.75,10.7) 116(5.25,10.7) 117(4.75,10.7) 118(4.25,10.7) 119(3.75,10.7) 120(3.25,10.7) 121(2.75,10.7) 122(2.25,10.7) 123(1.75,10.7) 124(1.25,10.7) 125(0.75,10.7) 126(0.25,10.7) 127(-0.25,10.7) 128(-0.75,10.7) 129(-1.25,10.7) 130(-1.75,10.7) 131(-2.25,10.7) 132(-2.75,10.7) 133(-3.25,10.7) 134(-3.75,10.7) 135(-4.25,10.7) 136(-4.75,10.7) 137(-5.25,10.7) 138(-5.75,10.7) 139(-6.25,10.7) 140(-6.75,10.7) 141(-7.25,10.7) 142(-7.75,10.7) 143(-8.25,10.7) 144(-8.75,10.7)
POT3_3352T
  rect 1.651x1.651 hole 1.016: 1(0,0)
  round 1.651 hole 1.016: 2(2.54,0) 3(5.08,0)
QFN8_1P6X1P6MM
  rect 0.457x0.33 smd: 1(-0.6,0.525)
  rect 0.457x0.279 smd: 2(-0.6,0) 3(-0.6,-0.5) 5(0.6,-0.5) 6(0.6,0) 7(0.6,0.5)
  rect 0.279x0.457 smd: 4(0,-0.6) 8(0,0.6)
QFN14_RGY
  rect 0.838x0.279 smd: 1(-1.725,-0.75) 7(1.725,-0.75) 8(1.725,0.75) 14(-1.725,0.75)
  rect 0.279x0.838 smd: 2(-1,-1.725) 3(-0.5,-1.725) 4(0,-1.725) 5(0.5,-1.725) 6(1,-1.725) 9(1,1.725) 10(0.5,1.725) 11(0,1.725) 12(-0.5,1.725) 13(-1,1.725)
  rect 2.032x2.032 smd: 15(0,0)
QFN32_S142EP
  custom 0.07x0.07 smd: 1(-2.4,1.751) 2(-2.4,1.251) 3(-2.4,0.751) 4(-2.4,0.25) 5(-2.4,-0.25) 6(-2.4,-0.751) 7(-2.4,-1.251) 8(-2.4,-1.751) 9(-1.751,-2.4) 10(-1.251,-2.4) 11(-0.751,-2.4) 12(-0.25,-2.4) 13(0.25,-2.4) 14(0.751,-2.4) 15(1.251,-2.4) 16(1.751,-2.4) 17(2.4,-1.751) 18(2.4,-1.251) 19(2.4,-0.751) 20(2.4,-0.25) 21(2.4,0.25) 22(2.4,0.751) 23(2.4,1.251) 24(2.4,1.751) 25(1.751,2.4) 26(1.251,2.4) 27(0.751,2.4) 28(0.25,2.4) 29(-0.25,2.4) 30(-0.751,2.4) 31(-1.251,2.4) 32(-1.751,2.4)
  rect 3.607x3.607 smd: 33(0,0)
RC0402_25
  round 0.635 smd: 1(-0.508,0) 2(0.508,0)
RC0603
  rect 0.991x0.813 smd: 1(-0.8,0) 2(0.8,0)
RC0603_OV
  oval 0.889x1.143 smd: 1(-0.762,0) 2(0.762,0)
RC0805_OV
  oval 0.889x1.524 smd: 1(-0.965,0) 2(0.965,0)
RC1206_OV
  oval 1.016x1.778 smd: 1(-1.524,0) 2(1.524,0)
SC74_6P_1P7X3P1
  rect 0.991x0.711 smd: 1(-1.2,0.95) 2(-1.2,0) 3(-1.2,-0.95) 4(1.2,-0.95) 5(1.2,0) 6(1.2,0.95)
SC_75
  rect 0.483x0.635 smd: 1(-0.5,-0.647) 2(0.5,-0.647) 3(0,0.647)
SO8_1P27_4X5
  rect 1.6x0.61 smd: 1(-2.7,1.905) 2(-2.7,0.635) 3(-2.7,-0.635) 4(-2.7,-1.905) 5(2.7,-1.905) 6(2.7,-0.635) 7(2.7,0.635) 8(2.7,1.905)
SO8_W
  rect 2.032x0.635 smd: 1(-3.632,1.905) 2(-3.632,0.635) 3(-3.632,-0.635) 4(-3.632,-1.905) 5(3.632,-1.905) 6(3.632,-0.635) 7(3.632,0.635) 8(3.632,1.905)
SOD-128
  rect 1.397x2.108 smd: A(-2.2,0) C(2.2,0)
SOT23-6_A
  rect 1.219x0.61 smd: 1(-1.25,0.95) 2(-1.25,0) 3(-1.25,-0.95) 4(1.25,-0.95) 5(1.25,0) 6(1.25,0.95)
SOT666
  rect 0.838x0.279 smd: 1(-0.725,0.5) 2(-0.725,0) 3(-0.725,-0.5) 4(0.725,-0.5) 5(0.725,0) 6(0.725,0.5)
SW4_SPST_4P8X3P6_2P5
  rect 1.499x0.991 smd: 1(2.575,0.85) 2(2.575,-0.85) 3(-2.575,0.85) 4(-2.575,-0.85)
TESTPOINT_135_070MIL
  rect 3.429x1.778 smd: 1(0,0)
TP_TH_063
  round 2.311 hole 1.6: 1(0,0)
TPAD_028
  round 0.711 smd: 1(0,0)
TPAD_030
  round 0.762 smd: 1(0,0)
TQFP176
  rect 1.524x0.305 smd: 1(-12.7,10.758) 2(-12.7,10.258) 3(-12.7,9.757) 4(-12.7,9.257) 5(-12.7,8.757) 6(-12.7,8.256) 7(-12.7,7.756) 8(-12.7,7.256) 9(-12.7,6.755) 10(-12.7,6.255) 11(-12.7,5.754) 12(-12.7,5.254) 13(-12.7,4.754) 14(-12.7,4.253) 15(-12.7,3.753) 16(-12.7,3.252) 17(-12.7,2.752) 18(-12.7,2.252) 19(-12.7,1.751) 20(-12.7,1.251) 21(-12.7,0.751) 22(-12.7,0.25) 23(-12.7,-0.25) 24(-12.7,-0.751) 25(-12.7,-1.251) 26(-12.7,-1.751) 27(-12.7,-2.252) 28(-12.7,-2.752) 29(-12.7,-3.252) 30(-12.7,-3.753) 31(-12.7,-4.253) 32(-12.7,-4.754) 33(-12.7,-5.254) 34(-12.7,-5.754) 35(-12.7,-6.255) 36(-12.7,-6.755) 37(-12.7,-7.256) 38(-12.7,-7.756) 39(-12.7,-8.256) 40(-12.7,-8.757) 41(-12.7,-9.257) 42(-12.7,-9.757) 43(-12.7,-10.258) 44(-12.7,-10.758) 89(12.7,-10.758) 90(12.7,-10.258) 91(12.7,-9.757) 92(12.7,-9.257) 93(12.7,-8.757) 94(12.7,-8.256) 95(12.7,-7.756) 96(12.7,-7.256) 97(12.7,-6.755) 98(12.7,-6.255) 99(12.7,-5.754) 100(12.7,-5.254) 101(12.7,-4.754) 102(12.7,-4.253) 103(12.7,-3.753) 104(12.7,-3.252) 105(12.7,-2.752) 106(12.7,-2.252) 107(12.7,-1.751) 108(12.7,-1.251) 109(12.7,-0.751) 110(12.7,-0.25) 111(12.7,0.25) 112(12.7,0.751) 113(12.7,1.251) 114(12.7,1.751) 115(12.7,2.252) 116(12.7,2.752) 117(12.7,3.252) 118(12.7,3.753) 119(12.7,4.253) 120(12.7,4.754) 121(12.7,5.254) 122(12.7,5.754) 123(12.7,6.255) 124(12.7,6.755) 125(12.7,7.256) 126(12.7,7.756) 127(12.7,8.256) 128(12.7,8.757) 129(12.7,9.257) 130(12.7,9.757) 131(12.7,10.258) 132(12.7,10.758)
  rect 0.305x1.524 smd: 45(-10.758,-12.7) 46(-10.258,-12.7) 47(-9.757,-12.7) 48(-9.257,-12.7) 49(-8.757,-12.7) 50(-8.256,-12.7) 51(-7.756,-12.7) 52(-7.256,-12.7) 53(-6.755,-12.7) 54(-6.255,-12.7) 55(-5.754,-12.7) 56(-5.254,-12.7) 57(-4.754,-12.7) 58(-4.253,-12.7) 59(-3.753,-12.7) 60(-3.252,-12.7) 61(-2.752,-12.7) 62(-2.252,-12.7) 63(-1.751,-12.7) 64(-1.251,-12.7) 65(-0.751,-12.7) 66(-0.25,-12.7) 67(0.25,-12.7) 68(0.751,-12.7) 69(1.251,-12.7) 70(1.751,-12.7) 71(2.252,-12.7) 72(2.752,-12.7) 73(3.252,-12.7) 74(3.753,-12.7) 75(4.253,-12.7) 76(4.754,-12.7) 77(5.254,-12.7) 78(5.754,-12.7) 79(6.255,-12.7) 80(6.755,-12.7) 81(7.256,-12.7) 82(7.756,-12.7) 83(8.256,-12.7) 84(8.757,-12.7) 85(9.257,-12.7) 86(9.757,-12.7) 87(10.258,-12.7) 88(10.758,-12.7) 133(10.758,12.7) 134(10.258,12.7) 135(9.757,12.7) 136(9.257,12.7) 137(8.757,12.7) 138(8.256,12.7) 139(7.756,12.7) 140(7.256,12.7) 141(6.755,12.7) 142(6.255,12.7) 143(5.754,12.7) 144(5.254,12.7) 145(4.754,12.7) 146(4.253,12.7) 147(3.753,12.7) 148(3.252,12.7) 149(2.752,12.7) 150(2.252,12.7) 151(1.751,12.7) 152(1.251,12.7) 153(0.751,12.7) 154(0.25,12.7) 155(-0.25,12.7) 156(-0.751,12.7) 157(-1.251,12.7) 158(-1.751,12.7) 159(-2.252,12.7) 160(-2.752,12.7) 161(-3.252,12.7) 162(-3.753,12.7) 163(-4.253,12.7) 164(-4.754,12.7) 165(-5.254,12.7) 166(-5.754,12.7) 167(-6.255,12.7) 168(-6.755,12.7) 169(-7.256,12.7) 170(-7.756,12.7) 171(-8.256,12.7) 172(-8.757,12.7) 173(-9.257,12.7) 174(-9.757,12.7) 175(-10.258,12.7) 176(-10.758,12.7)
UDFN6_1X1P5MM
  rect 0.584x0.305 smd: 1(-0.418,0.5)
  rect 0.508x0.305 smd: 2(-0.38,0) 3(-0.38,-0.5) 4(0.38,-0.5) 5(0.38,0) 6(0.38,0.5)
unnamed#2
  round 1.524 smd: (0,0)
XQFN8_1P45X1P25MM
  rect 0.787x0.203 smd: 1(-0.75,0)
  rect 0.203x0.711 smd: 2(-0.4,-0.65) 3(0,-0.65) 4(0.4,-0.65) 6(0.4,0.65) 7(0,0.65) 8(-0.4,0.65)
  rect 0.711x0.203 smd: 5(0.75,0)
XTAL2_3P3X2P6
  rect 1.6x2.718 smd: 1(-1,0) 2(1,0)
XTAL3_3P35X1P45_SM
  rect 0.406x2.108 smd: 1(1.2,0) 2(0,0) 3(-1.2,0)
XTLOSC4_SM
  rect 1.397x2.032 smd: 1(-2.54,-2.11) 2(2.54,-2.11) 3(2.54,2.11) 4(-2.54,2.11)

## Nets
GND: C1.2 C2.2 C3.2 C4.2 C5.2 C6.2 C7.2 C8.2 C9.2 C10.2 C11.2 C13.2 C14.2 C15.2 C16.2 C17.2 C18.2 C19.2 C20.2 C21.2 C22.2 C23.2 C24.2 C25.2 C26.2 C27.2 C28.2 C29.2 C30.2 C31.2 C32.2 C41.2 C43.2 C44.2 C45.2 C46.2 C47.2 C48.2 C49.2 C50.2 C53.2 C54.2 C55.2 C56.2 C57.2 C58.2 C59.2 C60.2 C61.2 C66.2 C68.2 C70.2 C71.2 C72.2 C73.2 C75.2 C77.2 C78.2 C79.2 C80.2 C81.2 C82.2 C83.2 C84.2 C85.2 C86.2 C87.2 C88.2 C89.2 C97.2 C99.2 C104.2 C108.2 C109.2 C110.2 C111.2 C112.2 C113.2 C114.2 C115.2 C116.2 C500.2 C501.2 C502.2 C503.2 C504.2 C505.2 C506.2 C507.2 C508.2 C509.2 C510.2 C511.2 C512.2 C513.2 C514.2 C515.2 C516.2 C517.2 C518.2 C519.2 C520.2 C521.2 C522.2 C523.2 C524.2 C525.2 C526.2 C527.2 C528.2 C529.2 C530.2 C531.2 C532.2 C533.2 C534.2 C535.2 C536.2 C537.2 C538.2 C539.2 C540.2 C541.2 C542.2 C543.2 C544.2 C545.2 C546.2 C547.2 C548.2 C549.2 C550.2 C551.2 D1.2(ANODE2) D2.2(ANODE2) D5.A GND1.1 GND2.1 GND3.1 GND4.1 GND5.1 J1.9 J1.12 J2.19 J3.12 J3.16 J3.18 J3.19 J5.12 J6.17 J9.2 J9.3 J9.SH1(SHIELD1) J9.SH2(SHIELD2) J10.3 J10.5 J10.15 J10.17 J10.19 J11.4 J13.4 J15.3(A2) J16.2 J16.6 J16.11 J16.12 J16.18 J16.22 J16.26 J16.29 J16.30 J16.34 J16.40 J16.46 J16.SH1 J16.SH2 J16.SH3 J16.SH4 J17.4 J20.3(A2) J20.5(A3) J24.5(GND) L501.2 P1.2(B1) P1.4(B2) P1.6(B3) P1.8(B4) P1.10(B5) P1.12(B6) P1.14(B7) P1.16(B8) P1.18(B9) P1.20(B10) P1.22(B11) P1.24(B12) P1.26(B13) P1.28(B14) P1.30(B15) P1.32(B16) P1.34(B17) P1.36(B18) P1.38(B19) P1.40(B20) P1.42(B21) P1.44(B22) P1.46(B23) P1.48(B24) P1.50(B25) Q1.2(EMITTER) Q2.2(EMITTER) Q3.2(EMITTER) Q500.2(EMITTER) Q501.2(EMITTER) R80.2 R92.2 R186.3(B) R228.2 R234.2 R248.2 R257.2 R296.2 R335.2 R336.2 R500.2 R502.2 R503.2 R608.2 R612.2 R623.2 R626.2 R629.2 R630.2 SW5.1 SW5.3 SW6.1 SW6.3 TP1.1(PIN1) TP3.1(PIN1) TP4.1(PIN1) TP56.1(PIN1) TP58.1(PIN1) TP59.1(PIN1) U1.4(SD) U1.5(GND1) U1.6(GND2) U1.7(GND3) U1.8(GND4) U3.4(GND) U7.12(VSS4) U7.15(VREFL) U7.16(VSS3) U7.31(VSS2) U7.50(VSS5) U7.66(VSS1) U7.90(VSS6) U7.123(VSS7) U8.19(VSS1) U8.22(VREFL) U8.23(VSS2) U8.38(VSS3) U8.58(VSS4) U8.76(VSS5) U8.109(VSS6) U8.130(VSS7) U8.151(VSS8) U8.171(VSS9) U9.4(GND1) U9.23(GND2) U9.45(GNDSMPS) U9.49(EPAD) U10.4(GND) U11.7(GND) U12.4(GND) U13.7(GND) U14.7(GND) U16.7(GND) U22.7(GND) U23.2(GND) U24.2(GND) U500.4(GND) U501.4(GND) U502.4(GND) U503.4(GND) U504.4(GND) U505.4(GND) U506.4(GND) U507.4(GND) U508.4(GND) U509.4(GND) U510.2(VSS1) U510.8(VSSA) U510.33(EPAD) U511.2(GND) U512.2(GND) U513.3(DIR) U513.4(GND) U514.2(GND) U515.2(GND) Y500.2(GND) Y501.2
P3V3_ENET: C549.1 C550.1 J16.1 J16.3 L4.2 R133.2 TPAD28.1(PIN1)
P3V3_ENETSW: C17.1 C18.1 C19.1 R142.1 R144.1 R185.1 R199.1 R201.1 R202.1 R521.1 R522.1 R551.1 R556.1 TPAD31.1(PIN1) U3.8(VCCB) U10.8(VCCB) U12.8(VCCB) U505.8(VCCB)
P3V3_SDA: C97.1 C533.1 C535.1 C536.1 C538.1 C539.1 C540.1 C545.1 J20.1(A1) R281.1 R285.2 R286.1 R288.1 R291.1 R301.1 R308.1 R605.1 R606.1 R607.1 R610.1 R613.1 R616.1 R621.1 R622.1 R631.1 TP55.1(PIN1) TPAD48.1(PIN1) U23.5(VCC) U509.1(VCCA) U510.1(VDD1) U510.7(VDDA) U510.11(VBAT) U511.1(VCCA) U512.1(VCCA) U513.7(VCCA) U514.1(VCCA)
P3V3_SW: C85.1 C99.1 C104.1 J3.10 J7.1 L4.1 L500.2 P1.1(A1) R41.1 R133.1 R182.2 R288.2 R501.2 R504.2 R521.2 R574.2 R633.2 TP26.1 TP53.1(PIN1) TPAD35.1(PIN1) TPAD50.1(PIN1) TS7.1
P5V0: C79.1 C112.1 C113.1 D6.A1(ANODE1) D6.A2(ANODE2) D6.A3(ANODE3) J3.13 J7.3 J8.2 J18.3 P1.49(A25) R6.1 R9.1 R12.1 R35.1 R181.2 R522.2 TP52.1(PIN1) TPAD2.1(PIN1) TPAD51.1(PIN1) TS12.1
P5V0_SDA_USB_CONN_VBUS: J24.1(VBUS) L9.1 U515.5(VCC)
P5V0_V1SBC: C31.1 C45.1 C47.1 J8.1 R132.1 R140.1 R517.2 R526.1 R531.1 TP5.1 TPAD7.1(PIN1) TS10.1 U9.6(V1)
P5V0_V2SBC: C526.1 C528.1 J15.1(A1) JP1.1 R204.1 U9.3(V2)
P5V_SDA: C89.1 C103.1 C111.1 L9.2 R293.1 R615.1 R628.1 U24.1(VIN) U510.6(VREGIN)
P5V_SDA_PSW: J8.3 TPAD49.1(PIN1) U24.6(VOUT)
VBAT: C12.1 C82.1 C86.1 D4.A J3.1 J3.3 J3.6 J3.22 J9.1 J13.2 J17.2 J18.1 R163.1 R180.2 TP2.1(PIN1) TP7.1(PIN1) TP8.1
VCC_HYPRFLASH: C529.1 C531.1 C532.1 L500.1 R574.1 R575.1 TPAD504.1(PIN1) U508.8(VCC)
VCCA_LS_SBC: C519.1 C520.1 C521.1 C522.1 R153.1 R525.2 R550.2 TP505.1(PIN1) U500.1(VCCA) U501.1(VCCA) U502.1(VCCA) U503.1(VCCA) U504.1(VCCA) U506.1(VCCA) U507.1(VCCA)
VCCA_VTRANSL: C46.1 C59.1 C61.1 C68.1 C80.1 C83.1 C527.1 C530.1 L7.2 R176.1 R242.2 R546.1 R547.1 R548.1 R570.1 R571.1 R572.1 R573.1 R576.1 R577.1 R578.1 R579.1 R582.1 R584.1 R588.1 R589.1 R593.1 R594.1 R597.1 R603.1 TPAD40.1(PIN1) TS8.1 U11.14(VCCB) U13.14(VCCB) U14.14(VCCB) U16.14(VCCB) U22.14(VCCB)
VCCB_VTRANSL: C32.1 C41.1 C53.1 C55.1 C56.1 C75.1 C81.1 C84.1 R181.1 R182.1 R214.1 R252.1 R258.1 R263.1 R273.1 R553.2 R557.1 R558.1 R559.1 R560.1 R566.1 R568.1 R569.1 R587.1 R592.1 R596.1 R598.1 R599.1 R600.1 R601.1 R602.1 TPAD45.1(PIN1) TS14.1 U11.1(VCCA) U13.1(VCCA) U14.1(VCCA) U16.1(VCCA) U22.1(VCCA)
VDD: J7.2 J19.2 R59.1 R60.1 R299.2 R505.2 TPAD12.1(PIN1) TPAD502.1(PIN1) TS15.1
VDD_MCU: C9.1 C23.1 C44.1 C50.1 C72.1 C73.1 C502.1 C503.1 C504.1 C505.1 C510.1 C516.1 C518.1 C524.1 C525.1 D2.1(ANODE1) J19.1 L1.1 R59.2 R509.2 TPAD32.1(PIN1) TPAD44.1(PIN1) TS4.1 U7.11(VDD2) U7.32(VDD1) U7.51(VDD4) U7.67(VDD3) U7.91(VDD5) U7.124(VDD6) U8.18(VDD1) U8.39(VDD2) U8.59(VDD3) U8.77(VDD4) U8.110(VDD5) U8.129(VDD6) U8.152(VDD7) U8.172(VDD8)
VDD_MCU_ENETSW: C27.1 C28.1 C517.1 L6.2 R156.1 R178.1 R179.2 R188.1 R190.1 R200.1 R207.1 R217.1 R539.1 R545.1 TPAD36.1(PIN1) U3.1(VCCA) U10.1(VCCA) U12.1(VCCA) U505.1(VCCA)
VDD_MCU_PERH: C2.1 C87.1 C88.1 C551.1 J3.4 J5.10 J6.14 J10.1 L6.1 L7.1 R36.1 R37.1 R60.2 R72.1 R90.1 R95.1 R107.1 R113.1 R121.1 R161.2 R179.1 R242.1 R518.1 R550.1 SW3.1 SW3.3 SW4.1 SW4.3 TP6.1(PIN1) TPAD17.1(PIN1) TS16.1
VDDA_MCU: C5.1 C6.1 C7.1 C506.1 C507.1 C508.1 C509.1 C511.1 D1.1(ANODE1) L1.2 R508.2 R509.1 TPAD14.1(PIN1) TS3.1 U7.13(VDDA) U8.20(VDDA)
ADC_POT: C48.1 R194.2 R583.1 R634.1 TP27.1(PIN1)
CAN_H: C20.1 J11.1 R112.2 R125.1 TP11.1(PIN1)
CAN_L: C25.1 J11.2 R135.2 R138.2 TP20.1(PIN1)
CANH_OUT: J3.21 R119.2
CANL_OUT: J3.24 R134.2
ENET_MII_TXC: J16.20 R96.1 R513.1 R514.1 TPAD21.1(PIN1)
ENETSW_INH: R2.2 R556.2 TPAD503.1(PIN1) U505.7(B1)
ENETSW_RESET: R1.2 R258.2 U22.4(A3)
ENETSW_RESET_A: R251.2 R261.2 R594.2 U22.11(B3)
ENETSW_SCL: R7.2 R199.2 TPAD3.1(PIN1) U10.6(B2)
ENETSW_SDA: R8.2 R185.2 TPAD5.1(PIN1) U10.7(B1)
ENETSW_SPI_MISO: R75.1 R202.2 TPAD13.1(PIN1) U12.6(B2)
ENETSW_SPI_MOSI: R108.1 R142.2 TPAD33.1(PIN1) U3.7(B1)
ENETSW_SPI_SC: R94.1 R201.2 TPAD37.1(PIN1) U12.7(B1)
ENETSW_SPI_SCK: R98.1 R144.2 TPAD34.1(PIN1) U3.6(B2)
EXP: U11.15(EXP) U13.15(EXP) U14.15(EXP) U16.15(EXP) U22.15(EXP)
HYPFLASH/QSPI_A_CS: R575.2 R581.2 U508.1(C\S\)
HYPFLASH/QSPI_A_IO0: R595.2 U508.5(SI/SIO0)
HYPFLASH/QSPI_A_IO1: R585.2 U508.2(SO/SIO1)
HYPFLASH/QSPI_A_IO2: R590.2 U508.3(W\P/SIO2)
HYPFLASH/QSPI_A_IO3: R586.2 U508.7(H\O\L\D\/SIO3)
HYPFLASH/QSPI_A_SCK: R591.2 U508.6(SCLK)
LED_BLUE: R222.2 R529.2
LED_GREEN: R245.2 R533.2
LED_RED: R255.2 R544.2
LEDRGB_BLUE: D6.C3(CATHODE3) R229.1 TP43.1(PIN1)
LEDRGB_GREEN: D6.C2(CATHODE2) R247.1 TP46.1(PIN1)
LEDRGB_RED: D6.C1(CATHODE1) R256.1 TP48.1(PIN1)
LIN1: C58.1 J13.1 R225.1 R226.1 R542.2 TP29.1(PIN1)
LIN1_OUT: J3.9 R543.2
LIN2: C77.1 J17.1 R276.1 R279.1 R535.2 TP51.1(PIN1)
LIN2_OUT: J3.15 R530.2
LVLRST_EN: R610.2 U509.5(OE)
MIC2005_CSLEW: C103.2 U24.5(CSLEW)
POWER_EN: R300.1 U510.31(ADC0_SE7B/PTD6/SPI0_PCS3/UART0_)
PTA0: R205.2 R302.2 U7.115(PTA0/FTM2_CH1/LPI2C0_SCLS/FXIO_) U8.140(PTA0/FTM2_CH1/LPI2C0_SCLS/FXIO_)
PTA0/ACMP0_IN0/ADC0_SE0: J4.15 R205.1
PTA1: R206.2 R274.2 U7.113(PTA1/FTM1_CH1/LPI2C0_SDAS/FXIO_) U8.138(PTA1/FTM1_CH1/LPI2C0_SDAS/FXIO_)
PTA1/ACMP0_IN1/ADC0_SE1: J4.18 R206.1
PTA2/LPUART0_RX: R40.1 R536.1 U7.105(PTA2/FTM3_CH0/LPI2C0_SDA/E\W\M\) U8.126(PTA2/FTM3_CH0/LPI2C0_SDA/E\W\M\)
PTA2/LPUART0_RX_LS: R129.1 TP10.1(PIN1) U504.6(B2)
PTA3/LPUART0_TX: R39.1 R540.1 U7.104(PTA3/FTM3_CH1/LPI2C0_SCL/EWM_IN) U8.125(PTA3/FTM3_CH1/LPI2C0_SCL/EWM_IN)
PTA3/LPUART0_TX_LS: R128.1 TP14.1(PIN1) U504.7(B1)
PTA4/CMP0_OUT/JTAG_TMS/SWD_DIO: R294.2 R507.2 U7.142(PTA4/CMP0_OUT/E\W\M\_\O\U\T\/JT) U8.173(PTA4/CMP0_OUT/E\W\M\_\O\U\T\/JT)
PTA5/TCLK1_2/RESET: D11.C(CATHODE) J22.1 R110.2 R251.1 R266.1 R289.2 R295.2 R537.1 TS6.1 U7.141(PTA5/TCLK1/R\E\S\E\T\) U8.170(PTA5/TCLK1/R\E\S\E\T\)
PTA6/FTM0_FLT1: J2.8 R282.1 U7.85(PTA6/FTM0_FLT1/LPSPI1_PCS1/FTM5) U8.104(PTA6/FTM0_FLT1/LPSPI1_PCS1/FTM5)
PTA7/FTM0_FLT2: J2.5 U7.83(PTA7/FTM0_FLT2/FTM5_CH3/RTC_CLK) U8.102(PTA7/FTM0_FLT2/FTM5_CH3/RTC_CLK)
PTA8/LPUART2_RX: R131.1 TP15.1(PIN1) U500.6(B2)
PTA8/LPUART2_RX/LPSPI2_SOUT/FXI: J3.20 R512.1 U7.144(PTA8/LPUART2_RX/LPSPI2_SOUT/FXI) U8.176(PTA8/LPUART2_RX/LPSPI2_SOUT/FXI)
PTA9/LPUART2_TX: R130.1 TP12.1(PIN1) U500.7(B1)
PTA9/LPUART2_TX/LPSPI2_PCS0/FXI: J3.23 R511.1 U7.143(PTA9/LPUART2_TX/LPSPI2_PCS0/FXI) U8.175(PTA9/LPUART2_TX/LPSPI2_PCS0/FXI)
PTA10/FTM1_CH4/FXIO_D0/JTAG_TDO: R515.2 U7.136(PTA10/FTM1_CH4/FXIO_D0/JTAG_TDO) U8.164(PTA10/FTM1_CH4/FXIO_D0/JTAG_TDO)
PTA11/FTM1_CH5/FXIO_D1/CMP0_RRT: J5.6 R324.1 U7.135(PTA11/FTM1_CH5/FXIO_D1/CMP0_RRT) U8.163(PTA11/FTM1_CH5/FXIO_D1/CMP0_RRT)
PTA12/FTM1_CH6/CAN1_RX/LPI2C1_S: J5.8 R325.1 U7.134(PTA12/FTM1_CH6/CAN1_RX/LPI2C1_S) U8.162(PTA12/FTM1_CH6/CAN1_RX/LPI2C1_S)
PTA13/FTM1_CH7/FTM2_QD_PHA/SAI0: J1.23 R326.1 U7.130(PTA13/FTM1_CH7/CAN1_TX/LPI2C1_S) U8.158(PTA13/FTM1_CH7/CAN1_TX/LPI2C1_S)
PTA14/FTM0_FLT0/FTM3_FLT1/SAI0_: J1.20 R329.1 U7.127(PTA14/FTM0_FLT0/FTM3_FLT1/EWM_I) U8.155(PTA14/FTM0_FLT0/FTM3_FLT1/EWM_I)
PTA15: R191.2 R304.2 U7.120(PTA15/FTM1_CH2/LPSPI0_PCS3/LPSP) U8.148(PTA15/FTM1_CH2/LPSPI0_PCS3/LPSP)
PTA15/FTM1_CH2/ADC1_SE12: J4.21 R191.1
PTA16: R193.2 R275.2 U7.119(PTA16/FTM1_CH3/LPSPI1_PCS2/ADC1) U8.146(PTA16/FTM1_CH3/LPSPI1_PCS2/ADC1)
PTA16/FTM1_CH3/ADC1_SE13: J4.24 R193.1
PTA17/FTM0_CH6/ENET_RESET: R261.1 R267.1 U7.92(PTA17/FTM0_CH6/FTM3_FLT0/E\W\M\) U8.111(PTA17/FTM0_CH6/FTM3_FLT0/E\W\M\)
PTA18/FTM4_CH0/LPUART1_TX/LPSPI: J6.16 U8.1(PTA18/FTM4_CH0/LPUART1_TX/LPSPI)
PTA19/FTM4_CH1/LPUART1_RX/LPSPI: J6.13 U8.2(PTA19/FTM4_CH1/LPUART1_RX/LPSPI)
PTA20/FTM4_CH2/LPSPI1_SIN: J6.15 U8.3(PTA20/FTM4_CH2/LPSPI1_SIN)
PTA21/FTM4_CH3/FXIO_D0/LPSPI1_P: J6.12 U8.6(PTA21/FTM4_CH3/FXIO_D0/LPSPI1_P)
PTA22/FTM4_CH4/FXIO_D1/LPSPI1_P: J6.9 U8.9(PTA22/FTM4_CH4/FXIO_D1/LPSPI1_P)
PTA23/FTM4_CH6/FXIO_D2: J6.6 U8.13(PTA23/FTM4_CH6/FXIO_D2)
PTA24/FTM4_CH7/FXIO_D3: J6.3 U8.16(PTA24/FTM4_CH7/FXIO_D3)
PTA25/FTM5_CH0: J2.2 R552.1 U7.10(PTA25/FTM5_CH0) U8.17(PTA25/FTM5_CH0)
PTA26/FTM5_CH1/LPSPI1_PCS0: R283.1 R564.1 U7.19(PTA26/FTM5_CH1/LPSPI1_PCS0/LPSP) U8.26(PTA26/FTM5_CH1/LPSPI1_PCS0/LPSP)
PTA26/FTM5_CH1/LPSPI1_PCS0_LS: R149.1 TP17.1(PIN1) U507.6(B2)
PTA27/FTM5_CH2/LPSPI1_SOUT/LP_1: R177.1 TP22.1(PIN1) U506.6(B2)
PTA27/FTM5_CH2/LPSPI1_SOUT/LPUA: J4.6 R555.1 U7.22(PTA27/FTM5_CH2/LPSPI1_SOUT/LPUA) U8.29(PTA27/FTM5_CH2/LPSPI1_SOUT/LPUA)
PTA28/FTM5_CH3/LPSPI1_SCK/LPU_1: R150.1 TP21.1(PIN1) U507.7(B1)
PTA28/FTM5_CH3/LPSPI1_SCK/LPUAR: J4.9 R563.1 U7.24(PTA28/FTM5_CH3/LPSPI1_SCK/LPUAR) U8.31(PTA28/FTM5_CH3/LPSPI1_SCK/LPUAR)
PTA29/FTM5_CH4/LPUART2_TX/LPS_1: R154.1 TP25.1(PIN1) U506.7(B1)
PTA29/FTM5_CH4/LPUART2_TX/LPSPI: J4.12 R554.1 U7.26(PTA29/FTM5_CH4/LPUART2_TX/LPSPI) U8.33(PTA29/FTM5_CH4/LPUART2_TX/LPSPI)
PTA30/FTM5_CH5: J2.4 U7.27(PTA30/FTM5_CH5/LPUART2_RX/LPSPI) U8.34(PTA30/FTM5_CH5/LPUART2_RX/LPSPI)
PTA31/FTM5_CH6: J2.1 U7.33(PTA31/FTM5_CH6/LPSPI0_PCS1) U8.40(PTA31/FTM5_CH6/LPSPI0_PCS1)
PTB0/SBC_LPSPI0_PCS0: J2.7 U7.78(PTB0/LPUART0_RX/LPSPI0_PCS0/LPT) U8.97(PTB0/LPUART0_RX/LPSPI0_PCS0/LPT)
PTB1/LPSPI0_SOUT: J2.10 U7.77(PTB1/LPUART0_TX/LPSPI0_SOUT/TCL) U8.96(PTB1/LPUART0_TX/LPSPI0_SOUT/TCL)
PTB2/LPSPI0_SCK: J2.16 U7.68(PTB2/FTM1_CH0/LPSPI0_SCK/FTM1_Q) U8.78(PTB2/FTM1_CH0/LPSPI0_SCK/FTM1_Q)
PTB3/LPSPI0_SIN: J2.13 U7.63(PTB3/FTM1_CH1/LPSPI0_SIN/FTM1_Q) U8.73(PTB3/FTM1_CH1/LPSPI0_SIN/FTM1_Q)
PTB4/MII_RMII_MDIO: R46.2 R268.2
PTB4/MII_RMII_MDIO/QSPI_B_IO0: R227.1 U7.41(PTB4/FTM0_CH4/LPSPI0_SOUT/MII_R) U8.49(PTB4/FTM0_CH4/LPSPI0_SOUT/MII_R)
PTB4/MII_RMII_MDIO/QSPI_B_IO0_1: R268.1 R602.2 U14.2(A1)
PTB4/MII_RMII_MDIO/QSPI_B_IO0__: R227.2 R572.2 U14.13(B1)
PTB5/ENET_MII_RMII_MDC: R38.2 R273.2 U22.2(A1)
PTB5/MII_RMII_MDC: R604.1 U7.40(PTB5/FTM0_CH5/LPSPI0_PCS1/LPSPI) U8.48(PTB5/FTM0_CH5/LPSPI0_PCS1/LPSPI)
PTB5/MII_RMII_MDC__A: R603.2 R604.2 U22.13(B1)
PTB6_XTAL: C3.1 R64.2 R76.1 R76.2 U7.18(PTB6/LPI2C0_SDA/XTAL) U8.25(PTB6/LPI2C0_SDA/XTAL) Y1.2
PTB7_EXTAL: C4.1 R64.1 R78.1 R78.2 U7.17(PTB7/LPI2C0_SCL/EXTAL) U8.24(PTB7/LPI2C0_SCL/EXTAL) Y1.1
PTB8/FTM3_CH0/SAI1_BCLK: J5.4 R318.1 U7.111(PTB8/FTM3_CH0/SAI1_BCLK) U8.136(PTB8/FTM3_CH0/SAI1_BCLK)
PTB9/FTM3_CH1/LPI2C0_SCLS: J6.10 R192.1 R319.1 U7.109(PTB9/FTM3_CH1/LPI2C0_SCLS/SAI1_) U8.133(PTB9/FTM3_CH1/LPI2C0_SCLS/SAI1_)
PTB10/FTM3_CH2/LPI2C0_SDAS: J6.7 R187.1 R315.1 U7.108(PTB10/FTM3_CH2/LPI2C0_SDAS/SAI1) U8.131(PTB10/FTM3_CH2/LPI2C0_SDAS/SAI1)
PTB11/FTM3_CH3/LPI2C0_HREQ: J2.17 U7.107(PTB11/FTM3_CH3/LPI2C0_HREQ) U8.128(PTB11/FTM3_CH3/LPI2C0_HREQ)
PTB12/FTM0_CH0/FTM3_FLT2/CAN2_R: J2.29 U7.98(PTB12/FTM0_CH0/FTM3_FLT2/CAN2_R) U8.119(PTB12/FTM0_CH0/FTM3_FLT2/CAN2_R)
PTB13/FTM0_CH1/FTM3_FLT1/CAN2_T: J2.26 U7.97(PTB13/FTM0_CH1/FTM3_FLT1/CAN2_T) U8.118(PTB13/FTM0_CH1/FTM3_FLT1/CAN2_T)
PTB14/FTM0_CH2/LPSPI1_SCK/ADC1_: J5.15 U7.96(PTB14/FTM0_CH2/LPSPI1_SCK/ADC1_) U8.116(PTB14/FTM0_CH2/LPSPI1_SCK/ADC1_)
PTB15/FTM0_CH3/LPSPI1_SIN/ADC1_: J5.17 U7.95(PTB15/FTM0_CH3/LPSPI1_SIN/ADC1_) U8.115(PTB15/FTM0_CH3/LPSPI1_SIN/ADC1_)
PTB16: R634.2 R635.2 U7.94(PTB16/FTM0_CH4/LPSPI1_SOUT/ADC1) U8.114(PTB16/FTM0_CH4/LPSPI1_SOUT/ADC1)
PTB16/FTM0_CH4/LPSPI1_SOUT/ADC1: J5.19 R635.1
PTB17/FTM0_CH5/LPSPI1_PCS3/FTM5: J2.14 R287.1 U7.93(PTB17/FTM0_CH5/LPSPI1_PCS3/FTM5) U8.112(PTB17/FTM0_CH5/LPSPI1_PCS3/FTM5)
PTB18/FTM5_CH7/LPSPI1_PCS1/ADC0: J2.11 U7.36(PTB18/FTM5_CH7/LPSPI1_PCS1/ADC0) U8.43(PTB18/FTM5_CH7/LPSPI1_PCS1/ADC0)
PTB19/FTM5_CH7: J6.24 U8.44(PTB19/FTM5_CH7)
PTB20/FTM6_CH0/ADC0_SE17: J6.1 R265.1 U7.37(PTB20/FTM6_CH0/ADC0_SE17) U8.45(PTB20/FTM6_CH0/ADC0_SE17)
PTB20/FTM6_CH0/ADC0_SE17__A: R265.2 R597.2 U22.12(B2)
PTB20/FTM6_CH0/ENET_INT: R5.2 R263.2 U22.3(A2)
PTB21/FTM6_CH1/ADC0_SE18: J6.4 U7.38(PTB21/FTM6_CH1/ADC0_SE18) U8.46(PTB21/FTM6_CH1/ADC0_SE18)
PTB22/FTM6_CH2/MII_CRS/LPUART1_: J3.5 U7.58(PTB22/FTM6_CH2/MII_CRS/LPUART1_) U8.66(PTB22/FTM6_CH2/MII_CRS/LPUART1_)
PTB23/FTM6_CH3/LPUART1_RX/MII_C: J3.2 U7.60(PTB23/FTM6_CH3/LPUART1_RX/MII_C) U8.68(PTB23/FTM6_CH3/LPUART1_RX/MII_C)
PTB24/FTM6_CH4: J1.18 U8.69(PTB24/FTM6_CH4)
PTB25/FTM6_CH5/LPSPI2_PCS0/ADC0: J3.17 R218.1 U7.62(PTB25/FTM6_CH5/LPSPI2_PCS0/ADC0) U8.71(PTB25/FTM6_CH5/LPSPI2_PCS0/ADC0)
PTB26/FTM6_CH6: J1.15 U8.72(PTB26/FTM6_CH6)
PTB27/FTM6_CH7/LPSPI2_SOUT/ADC0: J3.11 R221.1 U7.64(PTB27/FTM6_CH7/LPSPI2_SOUT/ADC0) U8.74(PTB27/FTM6_CH7/LPSPI2_SOUT/ADC0)
PTB28/FTM7_CH0/LPSPI2_SIN/ADC0_: J3.14 R183.1 U7.65(PTB28/FTM7_CH0/LPSPI2_SIN/ADC0_) U8.75(PTB28/FTM7_CH0/LPSPI2_SIN/ADC0_)
PTB29/FTM7_CH1/LPSPI2_SCK/ADC0_: J3.8 R184.1 U7.69(PTB29/FTM7_CH1/LPSPI2_SCK/ADC0_) U8.79(PTB29/FTM7_CH1/LPSPI2_SCK/ADC0_)
PTB30/FTM7_CH2: J1.6 U8.80(PTB30/FTM7_CH2)
PTB31/FTM7_CH3: R641.2 R642.1 U8.82(PTB31/FTM7_CH3)
PTC0/MII_RMII_RXD1: R63.2 R277.2
PTC0/MII_RMII_RXD1/QSPI_B_RWD_1: R259.2 R593.2 U16.13(B1)
PTC0/MII_RMII_RXD1/QSPI_B_RWDS: R259.1 U7.53(PTC0/FTM0_CH0/LPSPI2_SIN/MII_RM) U8.61(PTC0/FTM0_CH0/LPSPI2_SIN/MII_RM)
PTC0/MII_RMII_RXD1/QSPI_B_RWDS_: R277.1 R598.2 U16.2(A1)
PTC1/MII_RMII_RXD0: R74.2 R264.2
PTC1/MII_RMII_RXD0/QSPI_B_SCK: R253.1 U7.52(PTC1/FTM0_CH1/LPSPI2_SOUT/MII_R) U8.60(PTC1/FTM0_CH1/LPSPI2_SOUT/MII_R)
PTC1/MII_RMII_RXD0/QSPI_B_SCK_1: R253.2 R588.2 U16.12(B2)
PTC1/MII_RMII_RXD0/QSPI_B_SCK__: R264.1 R596.2 U16.3(A2)
PTC2/MII_RMII_TXD0: R102.2 R260.2
PTC2/MII_RMII_TXD0/QSPI_A_IO3: R249.1 U7.43(PTC2/FTM0_CH2/CAN0_RX/LPUART0_R) U8.51(PTC2/FTM0_CH2/CAN0_RX/LPUART0_R)
PTC2/MII_RMII_TXD0/QSPI_A_IO3_1: R249.2 R584.2 U16.11(B3)
PTC2/MII_RMII_TXD0/QSPI_A_IO3__: R254.1 R260.1 R592.2 U16.4(A3)
PTC2/QSPI_A_IO3: R254.2 R586.1
PTC3/MII_TX_ER: R55.1 R212.2
PTC3/MII_TX_ER/QSPI_A_CS/QSPI_1: R175.2 R546.2 U11.11(B3)
PTC3/MII_TX_ER/QSPI_A_CS/QSPI_2: R175.1 U7.42(PTC3/FTM0_CH3/CAN0_TX/LPUART0_T) U8.50(PTC3/FTM0_CH3/CAN0_TX/LPUART0_T)
PTC3/MII_TX_ER/QSPI_A_CS/QSPI_B: R212.1 R213.1 R568.2 U11.4(A3)
PTC3/QSPI_A_CS: R213.2 R581.1
PTC4/FTM1_CH0/RTC_CLKOUT/JTAG_T: R298.2 R510.2 U7.140(PTC4/FTM1_CH0/RTC_CLKOUT/EWM_IN) U8.169(PTC4/FTM1_CH0/RTC_CLKOUT/EWM_IN)
PTC5/FTM2_CH0/RTC_CLKOUT/JTAG_T: R516.2 U7.139(PTC5/FTM2_CH0/RTC_CLKOUT/LPI2C1) U8.168(PTC5/FTM2_CH0/RTC_CLKOUT/LPI2C1)
PTC6/LPUART1_RX/CAN1_RX/FTM3_CH: J6.11 R627.2 U7.118(PTC6/LPUART1_RX/CAN1_RX/FTM3_CH) U8.144(PTC6/LPUART1_RX/CAN1_RX/FTM3_CH)
PTC7/LPUART1_TX/CAN1_TX/FTM3_CH: J6.8 R620.2 U7.117(PTC7/LPUART1_TX/CAN1_TX/FTM3_CH) U8.143(PTC7/LPUART1_TX/CAN1_TX/FTM3_CH)
PTC8/LPUART1_RX: R34.1 R305.2 U7.81(PTC8/LPUART1_RX/FTM1_FLT0/FTM5_) U8.100(PTC8/LPUART1_RX/FTM1_FLT0/FTM5_)
PTC9/LPUART1_TX: R14.1 R619.2 U7.80(PTC9/LPUART1_TX/FTM1_FLT1/FTM5_) U8.99(PTC9/LPUART1_TX/FTM1_FLT1/FTM5_)
PTC10/FTM3_CH4/TRGMUX_IN11: J1.10 U7.75(PTC10/FTM3_CH4/TRGMUX_IN11) U8.94(PTC10/FTM3_CH4/TRGMUX_IN11)
PTC11/FTM3_CH5/FTM4_CH2/TRGMUX_: J1.7 U7.74(PTC11/FTM3_CH5/FTM4_CH2/TRGMUX_) U8.92(PTC11/FTM3_CH5/FTM4_CH2/TRGMUX_)
PTC12: R565.2 R567.2 U7.71(PTC12/FTM3_CH6/FTM2_CH6/LPUART2) U8.84(PTC12/FTM3_CH6/FTM2_CH6/LPUART2)
PTC12/BTN0: C109.1 R306.2 R565.1 TP507.1(PIN1)
PTC12/FTM3_CH6/FTM2_CH6/LPUART2: J6.5 R567.1
PTC13: R561.2 R562.2 U7.70(PTC13/FTM3_CH7/FTM2_CH7/LPUART2) U8.81(PTC13/FTM3_CH7/FTM2_CH7/LPUART2)
PTC13/BTN1: C110.1 R307.2 R562.1 TP506.1(PIN1)
PTC13/FTM3_CH7/FTM2_CH7/LPUART2: J6.2 R561.1
PTC14/FTM1_CH2/LPSPI2_PCS0/ADC0: J5.13 U7.61(PTC14/FTM1_CH2/LPSPI2_PCS0/MII_) U8.70(PTC14/FTM1_CH2/LPSPI2_PCS0/MII_)
PTC15/FTM1_CH3/LPSPI2_SCK/QSPI_: J5.2 U7.59(PTC15/FTM1_CH3/LPSPI2_SCK/MII_C) U8.67(PTC15/FTM1_CH3/LPSPI2_SCK/MII_C)
PTC16/MII_RMII_RX_ER: R61.1 R195.2
PTC16/MII_RMII_RX_ER/QSPI_B_I_1: R230.1 U7.57(PTC16/FTM1_FLT2/CAN2_RX/LPI2C1_) U8.65(PTC16/FTM1_FLT2/CAN2_RX/LPI2C1_)
PTC16/MII_RMII_RX_ER/QSPI_B_I_2: R230.2 R579.2 U13.10(B4)
PTC16/MII_RMII_RX_ER/QSPI_B_IO7: R195.1 R560.2 U13.5(A4)
PTC17/MII_RMII_RX_DV: R81.2 R196.2
PTC17/MII_RMII_RX_DV/QSPI_B_I_1: R231.2 R578.2 U13.11(B3)
PTC17/MII_RMII_RX_DV/QSPI_B_I_2: R231.1 U7.56(PTC17/FTM1_FLT3/CAN2_TX/LPI2C1_) U8.64(PTC17/FTM1_FLT3/CAN2_TX/LPI2C1_)
PTC17/MII_RMII_RX_DV/QSPI_B_IO6: R196.1 R559.2 U13.4(A3)
PTC18/FTM7_CH4: J2.3 U8.83(PTC18/FTM7_CH4)
PTC19/FTM7_CH5/ADC0_SE25: J5.11 U7.72(PTC19/FTM7_CH5/LPSPI2_PCS1/ADC0) U8.85(PTC19/FTM7_CH5/LPSPI2_PCS1/ADC0)
PTC20/FTM7_CH6: J2.6 U8.86(PTC20/FTM7_CH6)
PTC21/FTM7_CH7/FTM7_FLT0: J2.9 U8.87(PTC21/FTM7_CH7/FTM7_FLT0)
PTC22/FTM7_FLT1: J2.12 U8.88(PTC22/FTM7_FLT1)
PTC23/LPSPI0_SCK/ADC0_SE26: J4.1 U7.73(PTC23/LPSPI0_SCK/ADC0_SE26) U8.89(PTC23/LPSPI0_SCK/ADC0_SE26)
PTC24/FTM4_CH0: J2.15 U8.90(PTC24/FTM4_CH0)
PTC25/FTM4_CH1: J2.18 U8.91(PTC25/FTM4_CH1)
PTC26/FTM4_CH3: J2.21 U8.93(PTC26/FTM4_CH3)
PTC27/FTM4_CH4/FTM4_CH4/ADC0_SE: J4.4 U7.76(PTC27/FTM4_CH4/ADC0_SE27) U8.95(PTC27/FTM4_CH4/ADC0_SE27)
PTC28: R246.2 R583.2 U7.79(PTC28/FTM4_CH7/ADC0_SE28) U8.98(PTC28/FTM4_CH7/ADC0_SE28)
PTC28/FTM4_CH7/FTM4_CH7/ADC0_SE: J4.7 R246.1
PTC29/FTM5_CH2/FTM5_CH2/ADC0_SE: J4.10 U7.82(PTC29/FTM5_CH2/ADC0_SE29) U8.101(PTC29/FTM5_CH2/ADC0_SE29)
PTC30/FTM5_CH4/FXIO_D0/LPI2C1_S: J4.13 R320.1 U7.84(PTC30/FTM5_CH4/FXIO_D0/LPI2C1_S) U8.103(PTC30/FTM5_CH4/FXIO_D0/LPI2C1_S)
PTC31/FTM5_CH6/FXIO_D1/LPI2C1_S: J4.16 R313.1 U7.86(PTC31/FTM5_CH6/FXIO_D1/LPI2C1_S) U8.105(PTC31/FTM5_CH6/FXIO_D1/LPI2C1_S)
PTD0/FTM0_CH2/FTM2_CH0/TRACE_D0: J6.29 R122.2 U7.4(PTD0/FTM0_CH2/LPSPI1_SCK/FTM2_C) U8.8(PTD0/FTM0_CH2/LPSPI1_SCK/FTM2_C)
PTD1/FTM0_CH3/LPSPI1_SIN/FTM2_C: J5.18 R323.1 U7.3(PTD1/FTM0_CH3/LPSPI1_SIN/FTM2_C) U8.7(PTD1/FTM0_CH3/LPSPI1_SIN/FTM2_C)
PTD2/FTM3_CH4/LPSPI1_SOUT/FXIO_: J6.25 U7.102(PTD2/FTM3_CH4/LPSPI1_SOUT/FXIO_) U8.123(PTD2/FTM3_CH4/LPSPI1_SOUT/FXIO_)
PTD3/FTM3_CH5/LPSPI1_PCS0/FXIO_: J6.28 U7.101(PTD3/FTM3_CH5/LPSPI1_PCS0/FXIO_) U8.122(PTD3/FTM3_CH5/LPSPI1_PCS0/FXIO_)
PTD4/FTM0_FLT3/ADC1_SE6: J4.2 U7.100(PTD4/FTM0_FLT3/FTM3_FLT3/ADC1_S) U8.121(PTD4/FTM0_FLT3/FTM3_FLT3/ADC1_S)
PTD5/MII_TXD3: R115.2 R270.2
PTD5/MII_TXD3/QSPI_B_IO2: R580.1 U7.46(PTD5/FTM2_CH3/LPTMR0_ALT2/FTM2_) U8.54(PTD5/FTM2_CH3/LPTMR0_ALT2/FTM2_)
PTD5/MII_TXD3/QSPI_B_IO2__A: R570.2 R580.2 U14.11(B3)
PTD5/MII_TXD3/QSPI_B_IO2__B: R270.1 R600.2 U14.4(A3)
PTD6/MII_TXD2: R111.2 R269.2
PTD6/MII_TXD2/QSPI_B_IO1: R223.1 U7.45(PTD6/LPUART2_RX/FTM2_FLT2/MII_T) U8.53(PTD6/LPUART2_RX/FTM2_FLT2/MII_T)
PTD6/MII_TXD2/QSPI_B_IO1__A: R223.2 R571.2 U14.12(B2)
PTD6/MII_TXD2/QSPI_B_IO1__B: R269.1 R601.2 U14.3(A2)
PTD7/MII_RMII_TXD1: R109.2 R272.2
PTD7/MII_RMII_TXD1//QSPI_A_IO1: R224.1 U7.44(PTD7/LPUART2_TX/FTM2_FLT3/MII_R) U8.52(PTD7/LPUART2_TX/FTM2_FLT3/MII_R)
PTD7/MII_RMII_TXD1//QSPI_A_IO1_: R271.1 R272.1 R599.2 U14.5(A4)
PTD7/MII_RMII_TXD1//QSPI_A_IO_1: R224.2 R573.2 U14.10(B4)
PTD7/QSPI_A_IO1: R271.2 R585.1
PTD8/MII_RXD3: R58.2 R197.2
PTD8/MII_RXD3/QSPI_B_IO5: R232.1 U7.55(PTD8/LPI2C1_SDA/MII_RXD3/FTM2_F) U8.63(PTD8/LPI2C1_SDA/MII_RXD3/FTM2_F)
PTD8/MII_RXD3/QSPI_B_IO5__A: R232.2 R577.2 U13.12(B2)
PTD8/MII_RXD3/QSPI_B_IO5__B: R197.1 R558.2 U13.3(A2)
PTD9/MII_RXD2: R62.2 R198.2
PTD9/MII_RXD2/QSPI_B_IO4: R233.1 U7.54(PTD9/LPI2C1_SCL/FXIO_D0/FTM2_FL) U8.62(PTD9/LPI2C1_SCL/FXIO_D0/FTM2_FL)
PTD9/MII_RXD2/QSPI_B_IO4__A: R233.2 R576.2 U13.13(B1)
PTD9/MII_RXD2/QSPI_B_IO4__B: R198.1 R557.2 U13.2(A1)
PTD10/MII_RX_CLK: R79.2 R96.2 R137.2 R250.2
PTD10/MII_RX_CLK/QSPI_A_SCK: R243.1 U7.49(PTD10/FTM2_CH0/FTM2_QD_PHB/TRAC) U8.57(PTD10/FTM2_CH0/FTM2_QD_PHB/TRAC)
PTD10/MII_RX_CLK/QSPI_A_SCK__A: R243.2 R582.2 U16.10(B4)
PTD10/MII_RX_CLK/QSPI_A_SCK__B: R244.1 R250.1 R587.2 U16.5(A4)
PTD10/QSPI_A_SCK: R244.2 R591.1
PTD11/MII_RMII_TX_CLK: R123.2 R210.2 R514.2
PTD11/MII_RMII_TX_CLK/QSPI_A__1: R141.2 R173.1 U7.48(PTD11/FTM2_CH1/FTM2_QD_PHA/TRAC) U8.56(PTD11/FTM2_CH1/FTM2_QD_PHA/TRAC)
PTD11/MII_RMII_TX_CLK/QSPI_A__2: R210.1 R211.1 R569.2 U11.3(A2)
PTD11/MII_RMII_TX_CLK/QSPI_A_IO: R173.2 R547.2 U11.12(B2)
PTD11/QSPI_A_IO0: R211.2 R595.1
PTD12/MII_RMII_TX_EN: R91.2 R208.2
PTD12/MII_RMII_TX_EN/QSPI_A_I_1: R165.2 R548.2 U11.13(B1)
PTD12/MII_RMII_TX_EN/QSPI_A_I_2: R165.1 U7.47(PTD12/FTM2_CH2/LPI2C1_HREQ/TRAC) U8.55(PTD12/FTM2_CH2/LPI2C1_HREQ/TRAC)
PTD12/MII_RMII_TX_EN/QSPI_A_IO2: R208.1 R209.1 R566.2 U11.2(A1)
PTD12/QSPI_A_IO2: R209.2 R590.1
PTD13/FTM2_CH4/LPUART1_RX/ENET_: J5.20 R317.1 U7.35(PTD13/FTM2_CH4/LPUART1_RX/ENET_) U8.42(PTD13/FTM2_CH4/LPUART1_RX/ENET_)
PTD14/FTM2_CH5/LPUART1_TX/ENET_: J1.22 R322.1 U7.34(PTD14/FTM2_CH5/LPUART1_TX/ENET_) U8.41(PTD14/FTM2_CH5/LPUART1_TX/ENET_)
PTD15/FTM0_CH0/TRACE_D3/LPSPI0_: J1.19 R148.2 R332.1 U7.29(PTD15/FTM0_CH0/TRACE_D3/LPSPI0_) U8.36(PTD15/FTM0_CH0/TRACE_D3/LPSPI0_)
PTD16/FTM0_CH1/TRACE_D2/LPSPI0_: J1.16 R114.2 U7.28(PTD16/FTM0_CH1/TRACE_D2/LPSPI0_) U8.35(PTD16/FTM0_CH1/TRACE_D2/LPSPI0_)
PTD17/FTM0_FLT2/LPUART2_RX/FTM5: R639.1 R640.2 R643.2 U7.25(PTD17/FTM0_FLT2/LPUART2_RX/FTM5) U8.32(PTD17/FTM0_FLT2/LPUART2_RX/FTM5)
PTD18/FTM5_CH7/FXIO_D2/LPI2C1_S: J6.19 R321.1 U7.88(PTD18/FTM5_CH7/FXIO_D2/LPI2C1_S) U8.107(PTD18/FTM5_CH7/FXIO_D2/LPI2C1_S)
PTD19/FTM6_CH0/FXIO_D3/LPI2C1_S: J6.22 R314.1 U7.89(PTD19/FTM6_CH0/FXIO_D3/LPI2C1_S) U8.108(PTD19/FTM6_CH0/FXIO_D3/LPI2C1_S)
PTD20/FTM6_CH1: J1.24 U8.113(PTD20/FTM6_CH1)
PTD21/FTM6_CH2: J1.21 U8.117(PTD21/FTM6_CH2)
PTD22/FTM6_CH3/FTM6_CH3/ADC1_SE: J4.5 U7.99(PTD22/FTM6_CH3/ADC1_SE18) U8.120(PTD22/FTM6_CH3/ADC1_SE18)
PTD23/FTM6_CH4/FTM6_CH4/ADC1_SE: J4.8 U7.103(PTD23/FTM6_CH4/ADC1_SE19) U8.124(PTD23/FTM6_CH4/ADC1_SE19)
PTD24/FTM6_CH5/FTM6_CH5/ADC1_SE: J4.11 U7.106(PTD24/FTM6_CH5/ADC1_SE20) U8.127(PTD24/FTM6_CH5/ADC1_SE20)
PTD25/FTM6_CH6: J2.24 U8.132(PTD25/FTM6_CH6)
PTD26/FTM6_CH7/FXIO_D7: J2.27 U8.134(PTD26/FTM6_CH7/FXIO_D7)
PTD27/FTM7_CH0/FTM7_CH0/ADC1_SE: J4.14 U7.110(PTD27/FTM7_CH0/ADC1_SE21) U8.135(PTD27/FTM7_CH0/ADC1_SE21)
PTD28/FTM7_CH1/FTM7_CH1/ADC1_SE: J4.17 U7.112(PTD28/FTM7_CH1/ADC1_SE22) U8.137(PTD28/FTM7_CH1/ADC1_SE22)
PTD29/FTM7_CH2/FTM7_CH2/ADC1_SE: J4.20 R549.1 U7.114(PTD29/FTM7_CH2/ADC1_SE23) U8.139(PTD29/FTM7_CH2/ADC1_SE23)
PTD30/FTM7_CH3/FTM6_FLT1/ADC1_S: J4.23 U7.116(PTD30/FTM7_CH3/FTM6_FLT1/ADC1_S) U8.141(PTD30/FTM7_CH3/FTM6_FLT1/ADC1_S)
PTD31/FTM7_CH4/FXIO_D6/FTM6_FLT: J2.30 U8.142(PTD31/FTM7_CH4/FXIO_D6/FTM6_FLT)
PTE0/LPSPI0_SCK/TCLK1/LPI2C1_SD: J5.16 R328.1 U7.138(PTE0/LPSPI0_SCK/TCLK1/LPI2C1_SD) U8.166(PTE0/LPSPI0_SCK/TCLK1/LPI2C1_SD)
PTE1/LPSPI0_SIN/LPI2C0_HREQ/LPI: J5.14 R327.1 U7.137(PTE1/LPSPI0_SIN/LPI2C0_HREQ/LPI) U8.165(PTE1/LPSPI0_SIN/LPI2C0_HREQ/LPI)
PTE2/LPSPI0_SOUT/FTM3_CH6/SAI1_: J1.17 R316.1 U7.122(PTE2/LPSPI0_SOUT/LPTMR0_ALT3/FT) U8.150(PTE2/LPSPI0_SOUT/LPTMR0_ALT3/FT)
PTE3/FTM0_FLT0/FTM2_FLT0/CMP0_O: J1.14 U7.21(PTE3/FTM0_FLT0/LPUART2_RTS/FTM2) U8.28(PTE3/FTM0_FLT0/LPUART2_RTS/FTM2)
PTE4/CAN0_RX_LS: R127.1 TP13.1(PIN1) U502.6(B2)
PTE4/TRACE_D1/FTM2_CH2/CAN0_RX/: R136.2 R520.1 U7.9(PTE4/TRACE_D1/FTM2_QD_PHB/FTM2_) U8.15(PTE4/TRACE_D1/FTM2_QD_PHB/FTM2_)
PTE5/CAN0_TX_LS: R126.1 TP504.1(PIN1) U502.7(B1)
PTE5/TCLK2/FTM2_CH3/CAN0_TX/FXI: R519.1 U7.8(PTE5/TCLK2/FTM2_QD_PHA/FTM2_CH3) U8.14(PTE5/TCLK2/FTM2_QD_PHA/FTM2_CH3)
PTE6/LPSPI0_PCS2/FTM7_FLT1/FTM3: J1.11 U7.121(PTE6/LPSPI0_PCS2/FTM7_FLT1/FTM3) U8.149(PTE6/LPSPI0_PCS2/FTM7_FLT1/FTM3)
PTE7/FTM0_CH7/FTM3_FLT0: R637.1 R638.2 U7.87(PTE7/FTM0_CH7/FTM3_FLT0) U8.106(PTE7/FTM0_CH7/FTM3_FLT0)
PTE8/FTM0_CH6/MII_RMII_MDC/CMP0: J1.5 U7.39(PTE8/FTM0_CH6/MII_RMII_MDC/CMP0) U8.47(PTE8/FTM0_CH6/MII_RMII_MDC/CMP0)
PTE9/FTM0_CH7/LPUART2_CTS/ENET_: J1.2 R331.1 U7.30(PTE9/FTM0_CH7/LPUART2_CTS/ENET_) U8.37(PTE9/FTM0_CH7/LPUART2_CTS/ENET_)
PTE10/CLKOUT/LPSPI2_PCS1/FTM2_C: J2.20 R219.1 R310.1 U7.6(PTE10/CLKOUT/LPSPI2_PCS1/FTM2_C) U8.11(PTE10/CLKOUT/LPSPI2_PCS1/FTM2_C)
PTE11/FTM2_CH5/FXIO_D5: J2.23 R309.1 U7.5(PTE11/LPSPI2_PCS0/LPTMR0_ALT1/F) U8.10(PTE11/LPSPI2_PCS0/LPTMR0_ALT1/F)
PTE12/FTM0_FLT3/LPUART2_TX/FTM5: J6.20 U7.23(PTE12/FTM0_FLT3/LPUART2_TX/FTM5) U8.30(PTE12/FTM0_FLT3/LPUART2_TX/FTM5)
PTE13/FTM4_CH5/LPSPI2_PCS2/FTM2: J6.23 R220.1 U7.7(PTE13/FTM4_CH5/LPSPI2_PCS2/FTM2) U8.12(PTE13/FTM4_CH5/LPSPI2_PCS2/FTM2)
PTE14/FTM0_FLT1/FTM2_FLT1: J6.26 U7.20(PTE14/FTM0_FLT1/FTM2_FLT1) U8.27(PTE14/FTM0_FLT1/FTM2_FLT1)
PTE15/LPSPI2_SCK/FTM2_CH6/FTM4_: J2.28 R36.2 R312.1 U7.2(PTE15/LPUART1_CTS/LPSPI2_SCK/FT) U8.5(PTE15/LPUART1_CTS/LPSPI2_SCK/FT)
PTE16/LPSPI2_SIN/FTM2_CH7/FTM4_: J2.25 R37.2 R311.1 U7.1(PTE16/LPUART1_RTS/LPSPI2_SIN/FT) U8.4(PTE16/LPUART1_RTS/LPSPI2_SIN/FT)
PTE17/FTM7_CH5/FXIO_D5: J6.30 U8.145(PTE17/FTM7_CH5/FXIO_D5)
PTE18/FTM7_CH6/FXIO_D4: J6.27 U8.147(PTE18/FTM7_CH6/FXIO_D4)
PTE19/FTM7_CH7/FTM7_CH7/ADC1__1: J4.19 R528.1 U7.125(PTE19/FTM7_CH7/ADC1_SE25) U8.153(PTE19/FTM7_CH7/ADC1_SE25)
PTE19/FTM7_CH7/FTM7_CH7/ADC1_SE: R139.2 TP502.1(PIN1) U501.7(B1)
PTE20/FTM4_CH0/FTM4_CH0/ADC1__1: J4.22 R534.1 U7.126(PTE20/FTM4_CH0/ADC1_SE26) U8.154(PTE20/FTM4_CH0/ADC1_SE26)
PTE20/FTM4_CH0/FTM4_CH0/ADC1_SE: R124.2 TP501.1(PIN1) U501.6(B2)
PTE21: R541.1 R544.1 U7.128(PTE21/FTM4_CH1/ADC1_SE27) U8.156(PTE21/FTM4_CH1/ADC1_SE27)
PTE21/FTM4_CH1/FTM4_CH1/ADC1_SE: J5.1 R541.2
PTE22: R533.1 R538.1 U7.129(PTE22/FTM4_CH2/ADC1_SE28) U8.157(PTE22/FTM4_CH2/ADC1_SE28)
PTE22/FTM4_CH2/FTM4_CH2/ADC1_SE: J5.3 R538.2
PTE23: R524.1 R529.1 U7.131(PTE23/FTM4_CH3/ADC1_SE29) U8.159(PTE23/FTM4_CH3/ADC1_SE29)
PTE23/FTM4_CH3/FTM4_CH3/ADC1_SE: J5.5 R524.2
PTE24/FTM4_CH4/CAN2_TX/FTM4_CH4: J5.7 U7.132(PTE24/FTM4_CH4/CAN2_TX/ADC1_SE3) U8.160(PTE24/FTM4_CH4/CAN2_TX/ADC1_SE3)
PTE25/FTM4_CH5/CAN2_RX/CAN2_RX/: J5.9 U7.133(PTE25/FTM4_CH5/CAN2_RX/ADC1_SE3) U8.161(PTE25/FTM4_CH5/CAN2_RX/ADC1_SE3)
PTE26/FTM4_CH6: J6.18 U8.167(PTE26/FTM4_CH6)
PTE27/FTM4_CH7: J6.21 U8.174(PTE27/FTM4_CH7)
PVEXT_SBC: C54.1 C57.1 C60.1 R204.2 R527.1 R632.2 TPAD39.1(PIN1) TS11.1 U9.2(VEXT)
SAI0_BCLK: P1.11(A6) R325.2
SAI0_DATA0: P1.9(A5) R326.2
SAI0_DATA1: P1.7(A4) R327.2
SAI0_DATA2: P1.5(A3) R328.2
SAI0_DATA3: P1.3(A2) R329.2
SAI0_MCLK: P1.15(A8) R323.2
SAI0_SYNC: P1.13(A7) R324.2
SBC_CANH: R112.1 R119.1 U9.21(CANH)
SBC_CANL: R134.1 R135.1 U9.22(CANL)
SBC_EN: J15.7(A4) U9.5(EN)
SBC_HVIO1: J14.1(A1) R4.1 TP30.1(PIN1) U9.37(HVIO1)
SBC_HVIO2: J14.3(A2) R203.2 TP28.1(PIN1) U9.36(HVIO2)
SBC_HVIO3: J14.4(B2) U9.35(HVIO3)
SBC_HVIO4: J14.2(B1) U9.34(HVIO4)
SBC_HVIO5: J15.8(B4) U9.33(NC_33)
SBC_HVIO6: J15.6(B3) U9.32(NC_32)
SBC_HVIO7: J15.4(B2) U9.31(NC_31)
SBC_HVIO8: J15.2(B1) U9.30(NC_30)
SBC_LIMP: D7.C(CATHODE) J15.5(A3) U9.39(LIMP)
SBC_LIN_OUT1: R542.1 R543.1 U9.24(LIN1)
SBC_LIN_OUT2: R530.1 R535.1 U9.25(LIN2)
SBC_OE: R525.1 U500.5(OE) U501.5(OE) U502.5(OE) U503.5(OE) U504.5(OE) U506.5(OE) U507.5(OE)
SBC_RESET: R532.1 TP503.1(PIN1) U503.7(B1)
SDA_EXTAL: C534.1 U510.17(EXTAL0/PTA18/FTM0_FLT2/FTM_CLKI) Y501.3
SDA_JTAG_TCLK: J20.4(B2) R608.1 U510.12(JTAG_TCLK/SWD_CLK/EZP_CLK/TSI0_)
SDA_JTAG_TDI: J20.8(B4) R281.2 U510.13(JTAG_TDI/EZP_DI/TSI0_CH2/PTA1/U)
SDA_JTAG_TDO: J20.6(B3) R605.2 U510.14(JTAG_TDO/TRACE_SWO/EZP_DO/TSI0_)
SDA_JTAG_TMS: J20.2(B1) R606.2 U510.15(JTAG_TMS/SWD_DIO/TSI0_CH4/PTA3/)
SDA_LED: D10.C(CATHODE) U510.29(PTD4/SPI0_PCS1/U\A\R\T\0\_\R\T\)
SDA_LED_R: D10.A(ANODE) R308.2
SDA_RST: J20.10(B5) R607.2 R612.1 R615.2 TP510.1(PIN1) U510.19(R\E\S\E\T\)
SDA_RST_LED: D11.A(ANODE) R337.1
SDA_RST_TGTMCU_B: R636.2 U510.21(ADC0_SE9/TSI0_CH6/PTB1/I2C0_SDA)
SDA_RST_TGTMCU_J_B: J22.3 R295.1 R616.2 R636.1 U509.2(A1)
SDA_RX_EN: R630.1 R631.2 U514.5(DIR)
SDA_SPI0_CS: R290.2 TP511.1(PIN1) U510.23(ADC0_SE4B/CMP1_IN0/TSI0_CH15/PT)
SDA_SPI0_RST_B: R292.2 TP57.1(PIN1) U510.22(ADC0_SE15/TSI0_CH14/PTC1/SPI0_P)
SDA_SPI0_SCK: U510.26(PTC5/SPI0_SCK/LPTMR0_ALT2/I2S0_) U511.3(A)
SDA_SPI0_SIN: U510.28(CMP0_IN1/PTC7/SPI0_SIN/USB_SOF_) U513.5(2A)
SDA_SPI0_SOUT: U510.27(CMP0_IN0/PTC6/SPI0_SOUT/PDB0_EX) U512.3(A)
SDA_SWD_EN: R292.1 R624.1 U23.6(Y1)
SDA_SWD_EN_B: R609.2 U510.16(N\M\I\/E\Z\P\_\C\S\/TSI0_CH5/PT)
SDA_SWD_EN_B_R: R286.2 R609.1 U23.1(A1)
SDA_SWD_EN_R: R622.2 R623.1 R624.2 U511.5(DIR)
SDA_SWD_OE: R290.1 R625.1 U23.4(Y2)
SDA_SWD_OE_B: R284.2 U510.20(ADC0_SE8/TSI0_CH0/PTB0/I2C0_SCL)
SDA_SWD_OE_B_R: R284.1 R285.1 U23.3(A2)
SDA_SWD_OE_R: R621.2 R625.2 R626.1 U512.5(DIR)
SDA_USB_CONN_DN: J24.2(D-) U515.4(D-)
SDA_USB_CONN_DP: J24.3(D+) U515.6(D+)
SDA_USB_DN: R617.2 U510.4(USB0_DM)
SDA_USB_DP: R618.2 U510.3(USB0_DP)
SDA_USB_P5V_SENSE: R628.2 R629.1 U510.30(ADC0_SE6B/PTD5/SPI0_PCS2/U\A\R\)
SDA_USBSHIELD: J24.6(SHELL1) J24.7(SHELL2) J24.8(SHELL3) J24.9(SHELL4) J24.10(SHELL5) L501.1
SDA_VOUT33: C541.1 R291.2 U510.5(VOUT33)
SDA_XTAL: C537.1 U510.18(XTAL0/PTA19/FTM1_FLT0/FTM_CLKIN) Y501.1
SPLIT: C15.1 R125.2 R138.1
SW1_RST_B: C543.1 J22.2 SW5.2 SW5.4
SWD_CLK_TGTMCU_BUF: R298.1 U511.4(B)
SWD_DIO_TGTMCU_BUF: R294.1 U512.4(B) U513.2(2B)
TC_EXTAL_TP: TP508.1(PIN1) U510.10(EXTAL32)
TC_SDA_USB_ID_TP: J24.4(ID) TP512.1(PIN1)
TC_XTAL_TP: TP509.1(PIN1) U510.9(XTAL32)
TOUCH_ADC0_A: C108.1 R302.1 R330.1 TPAD52.1(PIN1)
TOUCH_ADC0_B: C78.1 R274.1 R278.1 TPAD46.1(PIN1)
TOUCH_ADC1_A: R304.1 R330.2 R333.1 TPAD53.1(PIN1)
TOUCH_ADC1_B: R275.1 R278.2 R280.1 TPAD47.1(PIN1)
UART1_RX_TGTMCU_BUF: R305.1 R627.1 U514.4(B)
UART1_RX_TGTMCU_R: U510.25(PTC4/SPI0_PCS0/UART1_TX/FTM0_CH) U514.3(A)
UART1_TX_TGTMCU_BUF: R619.1 R620.1 U513.1(1B)
UART1_TX_TGTMCU_R: U510.24(CMP1_IN1/PTC3/SPI0_PCS1/UART1_R) U513.6(1A)
V_TGTMCU: C542.1 C544.1 C546.1 R299.1 R337.2 R611.1 R614.1 TPAD54.1(PIN1) U509.8(VCCB) U511.6(VCCB) U512.6(VCCB) U513.8(VCCB) U514.6(VCCB)
VCAN_SBC: R526.2 R527.2 U9.20(VCAN)
VREFH: C1.1 J2.22 R506.2 TPAD6.1(PIN1)
VREFH_MCU: R506.1 R508.1 TPAD9.1(PIN1) TS1.1 U7.14(VREFH) U8.21(VREFH)
VSUP: C11.1 C13.1 C14.1 D4.C J12.1 J21.1 L2.1 R3.1 R13.1 R106.1 R189.1 R215.1 R262.1 R334.1 TP9.1(PIN1) TS5.1 U9.38(BATHS1)
VTRG_EN: R293.2 R296.1 R300.2 U24.3(ENABLE)
VTRG_FAULT_B: R301.2 U24.4(F\A\U\L\T\) U510.32(PTD7/CMT_IRO/UART0_TX/FTM0_CH7/)
N12195: C114.1 R306.1 R335.1 SW3.2 SW3.4 TP60.1(PIN1)
N12333: Q1.3(COLLECTOR) R229.2 TP42.1(PIN1)
N12731: C49.1 R186.2(WIPER) R194.1 TS9.1
N14568: C115.1 R307.1 R336.1 SW4.2 SW4.4 TP61.1(PIN1)
N16745305: C10.1 C12.2
N16745986: C16.1 C21.1 C22.1 L2.2 R106.2 TP16.1(PIN1) U9.26(BAT) U9.43(BATSMPS)
N16746162: C43.1 R163.2 TP24.1(PIN1) U9.28(BATSENSE)
N16749267: C62.2 C64.2 TP34.1(PIN1) U9.40(CAPB)
N16749274: C62.1 C64.1 TP37.1(PIN1) U9.41(CAPA)
N16751208: C63.2 C65.2 TP38.1(PIN1) U9.42(BOOTH1)
N16751220: C63.1 C65.1 L8.1 TP39.1(PIN1) U9.44(L1)
N16751253: C67.2 C69.2 TP40.1(PIN1) U9.48(BOOTH2)
N16751262: C67.1 C69.1 L8.2 TP47.1(PIN1) U9.46(L2)
N16752852: C29.1 U9.27(ADCCAP)
N16754051: C70.1 C71.1 R216.1 TP41.1(PIN1) U9.47(VSMPS)
N16755093: R139.1 R140.2 TPAD30.1(PIN1) U9.11(INTN1)
N16755100: R124.1 R132.2 TPAD29.1(PIN1) U9.13(INTN2)
N16755551: D8.A J12.2
N16755555: D8.C R225.2 R226.2 TP45.1(PIN1)
N16762105: J11.3 R180.1
N16823835: J10.6 R95.2 R515.1
N16823837: J10.8 R107.2 R516.1
N16823868: J10.2 R72.2 R507.1
N16823904: J10.10 R110.1 R518.2
N16823906: J10.4 R80.1 R90.2 R510.1
N16853763: R519.2 U502.2(A1)
N16853765: R520.2 U502.3(A2)
N16854069: R540.2 U504.2(A1)
N16854076: R536.2 U504.3(A2)
N16854778: C512.1 C513.1 C514.1 C515.1 R517.1 R523.1 R632.1 TP500.1(PIN1) U500.8(VCCB) U501.8(VCCB) U502.8(VCCB) U503.8(VCCB) U504.8(VCCB) U506.8(VCCB) U507.8(VCCB)
N16855430: C24.1 C26.1 C30.1 L3.2 R93.1 R97.1 R633.1 TPAD505.1(PIN1)
N16855432: C8.1 C501.1 D500.C TPAD15.1(PIN1) U1.1(VIN)
N16855436: D5.C L3.1 TPAD20.1(PIN1) U1.2(OUT)
N16855465: R92.1 R93.2 R97.2 TPAD23.1(PIN1) U1.3(FB)
N16855504: D500.A J18.2 TPAD8.1(PIN1) TS2.1
N16868078: R554.2 U506.2(A1)
N16868081: R555.2 U506.3(A2)
N16868084: R563.2 U507.2(A1)
N16868087: R564.2 U507.3(A2)
N16876903: Q2.3(COLLECTOR) R247.2 TP44.1(PIN1)
N16876912: Q3.3(COLLECTOR) R256.2 TP49.1(PIN1)
N16877035: Q1.1(BASE) R222.1 R228.1 TPAD38.1(PIN1)
N16877205: Q2.1(BASE) R245.1 R248.1 TPAD41.1(PIN1)
N16877232: Q3.1(BASE) R255.1 R257.1 TPAD43.1(PIN1)
N16920480: J1.8 R638.1 R640.1
N16979800: R161.1 R186.1(A)
N16990851: DS1.C(CATHODE) R4.2 R500.1
N16990853: DS2.C(CATHODE) Q500.3(COLLECTOR)
N16992788: DS3.C(CATHODE) Q501.3(COLLECTOR)
N16994780: DS1.A(ANODE) R13.2
N16994781: DS2.A(ANODE) R9.2
N16994782: DS3.A(ANODE) R12.2
N17033217: J16.60 R1.1
N17033342: J16.50 R38.1
N17036679: J16.4 R123.1 R137.1
N17037130: J16.10 R111.1
N17037131: J16.8 R115.1
N17037133: J16.42 R62.1
N17037134: J16.44 R58.1
N17037135: J16.28 R81.1
N17037137: J16.36 R74.1
N17037138: J16.38 R63.1
N17037139: J16.16 R102.1
N17037140: J16.32 R79.1
N17037141: J16.14 R109.1
N17037142: J16.24 R91.1
N17037216: J16.48 R46.1
N17037599: C500.1 R501.1 Y500.1(OE) Y500.4(VDD)
N17039052: J16.56 R5.1
N17047156: C547.1 J16.57 R35.2 R41.2 TPAD4.1(PIN1)
N17049594: R513.2 Y500.3(CLKOUT)
N17049891: C548.1 J16.59 R3.2 R6.2 TPAD1.1(PIN1)
N17061413: J16.52 R8.1
N17061419: J16.54 R7.1
N17062294: J16.47 R61.2
N17062316: J16.55 R55.2
N17063944: J16.5 TPAD25.1(PIN1)
N17070752: J16.15 TPAD22.1(PIN1)
N17070755: J16.17 TPAD19.1(PIN1)
N17070986: R207.2 R218.2 R219.2 R220.2 U12.2(A1)
N17073684: R184.2 R188.2 U3.3(A2)
N17073687: R183.2 R190.2 U3.2(A1)
N17074032: R217.2 R221.2 U12.3(A2)
N17074703: C523.1 R156.2 U3.5(OE) U10.5(OE) U12.5(OE) U505.5(OE)
N17076548: R178.2 R187.2 U10.2(A1)
N17076571: R192.2 R200.2 U10.3(A2)
N17077988: J16.31 R75.2
N17078013: J16.13 R94.2
N17078038: J16.9 R98.2
N17078063: J16.7 R108.2
N17085305: R617.1 U515.3(D-_PC)
N17085321: R618.1 U515.1(D+_PC)
N17090620: R611.2 U509.6(B2)
N17093251: R613.2 U509.3(A2)
N17094456: R289.1 R614.2 U509.7(B1)
N17104821: C66.1 R234.1 R552.2 R553.1 TPAD42.1(PIN1) U11.8(OE) U13.8(OE) U14.8(OE) U16.8(OE) U22.8(OE)
N17105995: R177.2 U9.7(SDI)
N17106020: R154.2 U9.8(SDO)
N17106045: R150.2 U9.9(SCK)
N17106070: R149.2 U9.10(SCSN)
N17106135: R128.2 U9.17(TXDL1)
N17106160: R129.2 U9.16(RXDL1)
N17106205: R126.2 U9.19(TXDC)
N17106230: R127.2 U9.18(RXDC)
N17109048: J16.58 R2.1
N17110598: D9.A J21.2
N17110600: D9.C R276.2 R279.2 TP54.1(PIN1)
N17111325: R130.2 U9.15(TXDL2)
N17111345: R131.2 U9.14(RXDL2)
N17121372: J10.20 R148.1
N17121375: J10.18 R141.1
N17121420: J10.12 R114.1
N17121423: J10.14 R122.1
N17121426: J10.16 R136.1
N17122140: J10.11 R113.2
N17122143: J10.13 R121.2
N17142860: R511.2 U500.2(A1)
N17142862: R512.2 U500.3(A2)
N17147847: J3.7 R266.2 R267.2 TP50.1(PIN1) TS13.1
N17164200: J1.1 R34.2 R40.2
N17164202: J1.4 R14.2 R39.2
N17164208: J1.13 R637.2 R639.2 R642.2
N17172615: Q500.1(BASE) R502.1 R504.1 TPAD501.1(PIN1)
N17172906: Q501.1(BASE) R503.1 R505.1 TPAD500.1(PIN1)
N17258367: J10.7 TPAD24.1(PIN1)
N17258370: J10.9 TPAD26.1(PIN1)
N17322992: J16.23 TPAD18.1(PIN1)
N17322995: J16.27 TPAD16.1(PIN1)
N17323030: J16.41 TPAD11.1(PIN1)
N17323033: J16.43 TPAD10.1(PIN1)
N17330326: J4.3 R282.2 R283.2 R287.2
N17344806: R528.2 U501.2(A1)
N17344809: R534.2 U501.3(A2)
N17345453: R537.2 U503.2(A1)
N17347641: R523.2 U503.6(B2)
N17349405: R531.2 R532.2 U9.12(RSTN)
N17376978: J1.3 R641.1 R643.1
N17381520: R545.2 R549.2 U505.2(A1)
N17382056: R539.2 U505.3(A2)
N17382061: R551.2 U505.6(B2)
N17414813: R189.2 U9.29(NC_29)
N17414865: R215.2 R216.2 U9.1(BATV2)
N17423098: D7.A(ANODE) R262.2
N17437399: C116.1 R203.1 R334.2 SW6.2 SW6.4
N17489769: R153.2 U503.3(A2)
N20564874: R252.2 U22.5(A4)
N20580503: R214.2 U11.5(A4)
N20620060: P1.17(A9) R322.2
N20620064: P1.27(A14) R317.2
N20620068: P1.45(A23) R332.2
N20620072: P1.47(A24) R331.2
N20620358: P1.31(A16) R315.2
N20620361: P1.29(A15) R316.2
N20620364: P1.25(A13) R318.2
N20620367: P1.23(A12) R319.2
N20620674: P1.21(A11) R320.2
N20620694: P1.19(A10) R321.2
N20620726: P1.33(A17) R314.2
N20620746: P1.35(A18) R313.2
N20620840: P1.37(A19) R312.2
N20620843: P1.39(A20) R311.2
N20620846: P1.41(A21) R310.2
N20620849: P1.43(A22) R309.2
N20712518: R333.2 SW2.1
N20712658: R280.2 SW1.1
N20743373: R589.2 U22.10(B4)
N20743518: R176.2 U11.10(B4)

Pads without a net: J13 3; J16 19 21 25 33 35 37 39 45 49 51 53; J17 3; J20 7 9; U11 6 9; U13 6 9; U14 6 9; U16 6 9; U22 6 9

## Via types
v1: diameter 0.508, hole 0.254, TOP to BOTTOM, 1042 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
GND: length 1897.8
  TOP w0.203: 80.29,61.94 U8.171 v1(82.91,61.94) ; 68.29,65.43 U8.23 68.29,67.4 68.28,67.4 68.28,67.78 68.29,67.79 v1(68.29,68.04) ; U7.15 70.29,65.28 ; v1(62.29,62.77) U7.31 62.29,65.28 ; 52.54,49.24 C50.2 53.05,49.74 ; U8.76 56.79,48.93 ; U7.12 71.79,65.28 ; 70.29,65.43 U8.19 ; 67.79,41.93 67.79,40.03 ; 60.79,65.43 U8.38 ; 68.29,42.08 U7.90 68.29,43.95 ; 68.79,65.43 U8.22 ; U7.16 69.79,65.28 ; 56.94,55.93 U7.50 ; 78.3,40.98 78.3,41.93 ; 56.94,47.93 U7.66 ; U8.58 56.79,57.93
  TOP w0.254: 33.62,53.05 C31.2 33.11,52.54 ; C89.2 14.82,19.57 ; C89.2 14.31,19.06 ; C89.2 15.33,19.06 ; C83.2 61.05,32.73 ; C83.2 61.05,31.2 ; C83.2 60.41,31.96 ; 118.2,78.19 C548.2 ; C548.2 119.22,78.19 ; C548.2 118.71,78.7 ; 29.53,30.72 C87.2 ; C87.2 29.53,31.74 ; C87.2 29.02,31.23 ; P1.24 56.77,5.55 ; P1.24 55.59,6.73 ; P1.24 55.59,4.37 ; P1.24 54.41,5.55 ; C58.2 8.85,46.95 ; C58.2 9.61,46.31 ; C58.2 8.09,46.31 ; 31.55,5.55 P1.42 ; P1.42 32.73,6.73 ; P1.42 32.73,4.37 ; P1.42 33.91,5.55 ; 46.79,5.55 P1.30 ; P1.30 49.15,5.55 ; P1.30 47.97,4.37 ; P1.30 47.97,6.73 ; 74.76,71.21 74.76,72.03 ; 74.76,71.21 73.94,71.21 ; 74.76,71.21 74.76,70.38 ; 74.76,71.21 75.59,71.21 ; 18.43,32.52 18.43,32.43 ; P1.8 75.91,6.73 ; P1.8 75.91,4.37 ; P1.8 77.09,5.55 ; P1.8 74.73,5.55 ; 35.52,23.07 J3.12 ; J3.12 34.51,24.09 ; J3.12 35.52,25.11 ; 3.64,49.74 J11.4 ; J11.4 4.66,50.76 ; J11.4 2.63,50.76 ; J11.4 3.64,51.78 ; J16.SH2 113.75,68.67 ; J16.SH2 114.16,66.13 ; J16.SH2 113.35,66.13 ; J16.SH2 113.75,63.59 ; 85.88,66.38 J10.3 ; J10.3 87.46,65.82 ; J10.3 89.05,66.38 ; J10.3 87.46,66.94 ; P1.28 51.69,5.55 ; P1.28 49.33,5.55 ; P1.28 50.51,6.73 ; P1.28 50.51,4.37 ; 73.75,70.95 73.75,70.95 ; 40.29,47.65 U11.7 ; U11.7 40.29,48.31 ; U11.7 40.9,47.98 ; U7.50 v1(58.98,55.93) ; 10.43,33.87 C77.2 ; C77.2 10.43,35.39 ; C77.2 11.06,34.63 ; 24.09,12.02 C112.2 23.58,12.53 ; J3.18 40.6,25.11 ; J3.18 39.59,24.09 ; J3.18 40.6,23.07 ; U12.4 101.62,45.28 ; J6.17 78.7,80.99 ; J6.17 78.7,78.95 ; J6.17 79.72,79.97 ; 27.39,32.47 C82.2 28.41,32.47 ; 41.56,37.49 U14.7 ; U14.7 41.56,38.15 ; U14.7 42.17,37.82 ; U16.7 52.86,38.13 ; U16.7 52.53,38.74 ; U16.7 52.2,38.13 ; P1.32 46.61,5.55 ; P1.32 45.43,4.37 ; P1.32 45.43,6.73 ; P1.32 44.25,5.55 ; C86.2 46.7,31.89 ; C86.2 47.21,31.38 ; C86.2 46.7,30.87 ; J16.22 112.22,67.05 ; 11.07,8.68 SW5.3 ; SW5.3 10.39,9.62 ; SW5.3 11.07,10.56 ; SW5.3 11.76,9.62 ; 86.32,25.6 J5.12 ; J5.12 85.29,26.63 ; J5.12 87.35,26.63 ; J5.12 86.32,27.66 ; 58.13,4.37 P1.22 ; P1.22 56.95,5.55 ; P1.22 58.13,6.73 ; P1.22 59.31,5.55 ; 10.39,4.47 SW5.1 ; SW5.1 11.76,4.47 ; SW5.1 11.07,5.41 ; SW5.1 11.07,3.53 ; J9.3 12.29,67.37 ; J9.3 10.38,68.28 ; J9.3 8.46,67.37 ; 34.51,46.47 C55.2 ; C55.2 35.27,45.83 ; C55.2 36.03,46.47 ; J17.4 4.66,23.07 ; J17.4 3.64,24.09 ; J17.4 3.64,22.06 ; J17.4 2.63,23.07 ; C1.2 25.87,75.27 ; C1.2 25.87,74.25 ; C1.2 25.36,74.76 ; 85.88,56.22 J10.19 ; J10.19 87.46,56.78 ; J10.19 87.46,55.66 ; J10.19 89.05,56.22 ; 87.46,56.93 J10.17 ; J10.17 85.88,57.49 ; J10.17 89.05,57.49 ; J10.17 87.46,58.05 ; 78.3,40.98 v1(78.3,39.79) ; 50.13,31.58 C80.2 50.89,30.95 ; 64.99,71.08 C3.2 64.48,71.59 ; U13.7 43.32,45.62 ; U13.7 43.32,44.96 ; U13.7 42.71,45.29 ; U7.12 v1(71.79,63.24) ; 83.27,71.21 84.1,71.21 ; 83.27,71.21 82.45,71.21 ; 83.27,71.21 83.27,70.38 ; 83.27,71.21 83.27,72.03 ; 29.01,5.55 P1.44 ; P1.44 30.19,4.37 ; P1.44 31.37,5.55 ; P1.44 30.19,6.73 ; P1.36 40.35,6.73 ; P1.36 39.17,5.55 ; P1.36 41.53,5.55 ; P1.36 40.35,4.37 ; C66.2 52.54,42.12 ; C66.2 52.54,40.6 ; C66.2 53.18,41.36 ; J1.12 55.84,83.53 ; J1.12 54.83,82.51 ; J1.12 55.84,81.49 ; J1.12 56.86,82.51 ; 73.37,4.37 P1.10 ; P1.10 74.55,5.55 ; P1.10 72.19,5.55 ; P1.10 73.37,6.73 ; 53.05,4.37 P1.26 ; P1.26 53.05,6.73 ; P1.26 54.23,5.55 ; P1.26 51.87,5.55 ; P1.12 70.83,6.73 ; P1.12 72.01,5.55 ; P1.12 70.83,4.37 ; P1.12 69.65,5.55 ; 33.95,44.73 C57.2 34.58,45.68 ; P1.14 69.47,5.55 ; P1.14 68.29,6.73 ; P1.14 67.11,5.55 ; P1.14 68.29,4.37 ; U8.76 v1(54.65,48.93) ; C27.2 97.5,56.47 ; 112.22,68.05 J16.26 109.55,68.05 ; 109.55,73.05 J16.46 112.22,73.05 ; J16.SH1 113.75,62.7 ; J16.SH1 113.35,61.24 ; J16.SH1 113.75,59.78 ; J16.SH1 114.16,61.24 ; 26.47,5.55 P1.46 ; P1.46 27.65,4.37 ; P1.46 28.83,5.55 ; P1.46 27.65,6.73 ; 113.35,72.48 J16.SH3 ; J16.SH3 114.16,72.48 ; J16.SH3 113.75,69.94 ; J16.SH3 113.75,75.02 ; U8.19 70.29,67.4 70.29,67.4 70.29,67.78 70.3,67.8 70.3,67.84 70.29,67.84 v1(70.29,68.16) ; J2.19 26.38,78.45 ; J2.19 25.36,77.43 ; J2.19 27.39,77.43 ; 87.46,65.11 89.05,65.11 ; 87.46,65.11 85.88,65.11 ; 87.46,65.11 87.46,64.55 ; 87.46,65.11 87.46,65.67 ; 3.64,36.15 J13.4 ; J13.4 2.63,37.17 ; J13.4 4.66,37.17 ; J13.4 3.64,38.19 ; U7.123 78.12,51.93 v1(77.91,51.72) ; 64.57,5.55 P1.16 ; P1.16 65.75,4.37 ; P1.16 65.75,6.73 ; P1.16 66.93,5.55 ; 119.6,48.73 R186.3 ; R186.3 120.61,47.71 ; R186.3 120.61,49.74 ; R186.3 121.63,48.73 ; J9.SH2 5.13,63.57 ; J9.SH2 3.08,64.48 ; J9.SH2 3.08,62.65 ; J9.SH2 1.02,63.57 ; 109.55,64.55 J16.12 112.22,64.55 ; J9.SH1 3.08,74.38 ; J9.SH1 1.02,73.47 ; J9.SH1 3.08,72.55 ; J9.SH1 5.13,73.47 ; U7.16 v1(69.79,63.24) ; J16.18 112.22,66.05 ; P1.40 35.27,6.73 ; P1.40 34.09,5.55 ; P1.40 36.45,5.55 ; P1.40 35.27,4.37 ; 78.96,38.82 78.96,38.71 ; R80.2 96.74,68.41 ; 122.01,58.98 C550.2 ; C550.2 122.64,59.93 ; C550.2 122.01,60.88 ; P1.48 25.11,6.73 ; P1.48 23.93,5.55 ; P1.48 26.29,5.55 ; P1.48 25.11,4.37 ; 117.95,69.05 J16.29 115.29,69.05 ; 8.46,72.57 J9.2 ; J9.2 10.38,71.65 ; J9.2 12.29,72.57 ; J9.2 10.38,73.48 ; 5.06,14.47 J24.5 3.31,14.47 ; 79.81,5.55 P1.4 ; P1.4 80.99,4.37 ; P1.4 80.99,6.73 ; P1.4 82.17,5.55 ; 19.8,17.33 C97.2 ; C97.2 20.31,17.84 ; C97.2 19.29,17.84 ; 12.61,4 C116.2 ; C116.2 13.37,3.36 ; C116.2 14.14,4 ; 78.45,4.37 P1.6 ; P1.6 78.45,6.73 ; P1.6 79.63,5.55 ; P1.6 77.27,5.55 ; 93.04,49.43 U10.4 92.49,49.72 ; J16.6 112.22,63.05 ; 36.54,35.65 C75.2 ; C75.2 37.3,36.28 ; C75.2 35.78,36.28 ; 20.41,10.75 C113.2 21.04,9.99 ; 31.29,37.83 31.46,37.83 ; 109.55,70.05 J16.34 112.22,70.05 ; C549.2 121.09,61.96 ; C549.2 121.6,61.45 ; C549.2 121.09,60.94 ; C68.2 37.3,40.85 ; C68.2 35.78,40.85 ; C68.2 36.54,41.49 ; P1.50 22.57,6.73 ; P1.50 23.75,5.55 ; P1.50 21.39,5.55 ; P1.50 22.57,4.37 ; 97.62,56.47 C28.2 ; J10.15 89.05,58.76 ; J10.15 87.46,58.2 ; J10.15 87.46,59.32 ; J10.15 85.88,58.76 ; 64.42,37.24 U22.7 64.08,37.85 ; C46.2 35.32,52.18 ; P1.34 42.89,6.73 ; P1.34 42.89,4.37 ; P1.34 44.07,5.55 ; P1.34 41.71,5.55 ; U8.38 v1(60.79,67.57) ; C88.2 85.31,23.89 ; C88.2 84.8,23.38 ; C88.2 84.8,24.39 ; P1.20 61.85,5.55 ; P1.20 60.67,6.73 ; P1.20 60.67,4.37 ; P1.20 59.49,5.55 ; C111.2 7.4,13.37 ; C111.2 6.9,12.86 ; C111.2 7.4,12.35 ; 62.03,5.55 P1.18 ; P1.18 64.39,5.55 ; P1.18 63.21,4.37 ; P1.18 63.21,6.73 ; 85.56,65.47 C551.2 85.05,64.96 ; C79.2 37.05,33.08 ; C79.2 37.05,32.06 ; C79.2 36.54,32.57 ; 32.93,31.84 C85.2 ; C85.2 33.44,31.33 ; C85.2 33.44,32.35 ; 112.22,71.55 J16.40 109.55,71.55 ; 9.6,15.12 U24.2 11.2,15.12 ; 87.96,37.69 Q2.2 ; 85.43,51.52 C44.2 ; C44.2 85.43,52.54 ; C44.2 85.94,52.03 ; 103.09,13.93 103.01,13.93 ; 32.98,44.54 C60.2 33.49,44.03 ; 36.63,5.55 P1.38 ; P1.38 37.81,6.73 ; P1.38 38.99,5.55 ; P1.38 37.81,4.37 ; C84.2 66.26,31.96 ; C84.2 65.62,32.73 ; C84.2 65.62,31.2 ; 58.38,81.49 J1.9 ; J1.9 59.4,82.51 ; J1.9 57.37,82.51 ; J1.9 58.38,83.53 ; U8.22 v1(68.79,67.57) ; 88.47,35.83 Q3.2 87.96,35.4 ; 13.04,62.39 C15.2 11.52,62.39 ; R296.2 7.71,16.01 ; 82.35,5.55 P1.2 ; P1.2 83.53,6.73 ; P1.2 83.53,4.37 ; P1.2 84.71,5.55 ; R248.2 87.82,37.68 ; 112.22,69.05 J16.30 109.55,69.05 ; 53.18,31.58 C81.2 52.41,30.95 ; 113.75,75.91 J16.SH4 ; J16.SH4 114.16,77.37 ; J16.SH4 113.35,77.37 ; J16.SH4 113.75,78.83 ; 109.55,62.05 J16.2 ; J16.2 112.22,62.05 ; J16.2 110.89,61.72 ; 115.29,64.55 J16.11 ; 87.34,35.39 87.85,35.39 ; U7.66 v1(58.98,47.93) ; C21.2 31.74,59.09 ; 47.46,55.84 C26.2 ; 52.29,40.35 R234.2 52.79,39.84 ; U3.4 101.87,53.16 ; C45.2 33.95,52.6 ; U8.58 v1(54.65,57.93) ; C22.2 30.72,59.07 ; 18.14,4.42 17.95,4.42
  TOP w0.279: U7.15 70.29,63.4 ; 27.3,50.15 U9.4 25.42,50.15 ; U7.123 81.24,51.93 U8.151 ; U9.45 22.29,47.02 ; 17.74,56.53 U9.23
  TOP w0.406: 87.34,34.83 87.34,35.39 86.78,35.39
  TOP w0.457: 53.05,58.25 53.05,58.76 ; 53.05,58.25 53.56,58.25 ; 53.05,58.25 52.54,58.25 ; Q2.2 88.98,37.69 ; Q2.2 88.47,38.09 ; Q2.2 88.47,37.25 ; Q1.2 88.44,40.05 ; Q1.2 88.95,40.48 ; Q1.2 88.44,40.88 ; C72.2 79.46,38.31 ; C72.2 78.96,38.71 ; C72.2 78.96,37.81 ; C78.2 101.31,34.5 ; C78.2 102.07,33.87 ; C78.2 100.55,33.87 ; 67.53,38.31 C73.2 67.02,37.81 ; 88.48,34.83 88.47,34.85 Q3.2 89.11,35.4 89.12,35.39 ; 87.31,37.17 R248.2 86.8,37.68
  TOP w0.508: 51.14,47.84 C53.2 50.51,48.6 ; U1.8 49.38,73.4 ; U1.8 49.87,72.41 ; U1.8 50.37,73.4 ; U1.8 49.87,74.41 ; 103.01,13.93 C108.2 ; C108.2 102.32,14.57 ; C108.2 101.56,13.93 ; C99.2 85.81,17.23 ; C99.2 86.32,16.72 ; C99.2 85.81,16.22 ; U1.4 53.68,67.01 ; U1.4 54.18,68 ; U1.4 53.68,68.99 ; U1.4 53.19,68 ; C25.2 7.91,55.74 ; C25.2 7.4,55.23 ; C25.2 6.9,55.74 ; C4.2 69.81,71.59 ; C4.2 70.32,71.08 ; C4.2 70.83,71.59 ; 102.2,60.28 C19.2 101.43,60.92 ; 11.9,55.33 C29.2 11.39,54.82 ; SW6.1 17.45,3.48 ; SW6.1 17.95,4.42 ; SW6.1 16.76,4.42 ; SW6.1 17.45,5.36 ; C104.2 86.7,15.2 ; C104.2 86.07,15.96 ; C104.2 86.07,14.44 ; 96.61,12.99 96.61,13.5 ; 96.61,12.99 96.1,12.99 ; 96.61,12.99 96.61,12.48 ; 69.81,70.32 C6.2 70.32,70.83 ; C2.2 85.05,75.02 ; C2.2 85.56,74.51 ; C2.2 85.05,74 ; 97.62,60.28 C17.2 98.39,60.92 ; C48.2 110.83,48.35 ; C48.2 111.34,47.84 ; C48.2 111.85,48.35 ; C109.2 94.68,13.5 ; C109.2 95.19,12.99 ; C109.2 94.68,12.48 ; C5.2 72.22,70.95 ; C5.2 73.75,70.95 ; C5.2 72.99,71.59 ; SW6.3 18.14,9.57 ; SW6.3 16.76,9.57 ; SW6.3 17.45,8.57 ; R92.2 53.94,66.13 ; R92.2 53.43,66.64 ; R92.2 53.43,65.62 ; 96.74,57.11 C27.2 95.97,56.47 ; 71.84,70.32 C7.2 71.34,70.83 ; 95.11,6.18 R335.2 95.62,5.67 ; 99.15,56.47 C28.2 98.39,57.11 ; C49.2 114.9,48.35 ; C49.2 115.4,47.84 ; C49.2 115.91,48.35 ; 94.07,6.18 C114.2 93.56,5.67 ; C9.2 62.95,70.64 ; C9.2 63.59,69.68 ; C9.2 62.95,68.73 ; 100.29,5.62 C115.2 100.8,6.13 ; 11.9,51.78 C43.2 11.39,52.28 ; 86.88,40.47 R228.2 87.39,39.96 ; C18.2 99.91,60.92 ; C20.2 6.9,58.74 ; C20.2 7.4,59.24 ; C20.2 7.91,58.74 ; 51.14,43.27 C61.2 50.51,42.5 ; 52.41,73.4 51.92,73.4 ; 52.41,73.4 52.41,74.39 ; 52.41,73.4 52.41,72.41 ; 52.41,73.4 52.91,73.4 ; U1.5 53.68,74.39 ; U1.5 53.19,73.4 ; U1.5 53.68,72.41 ; U1.5 54.18,73.4 ; 102.27,5.62 R336.2 101.77,6.13 ; U1.7 50.65,73.4 ; U1.7 51.64,73.4 ; U1.7 51.14,72.41 ; U1.7 51.14,74.39 ; C45.2 C47.2 C54.2 C57.2 ; C56.2 51.14,46.31 ; C59.2 51.14,44.79
  TOP w0.635: C41.2 45.81,54.19 ; 47.46,57.36 C24.2 48.09,58.13 ; D5.A 44.26,56.64 ; D5.A 43.01,57.53 ; D5.A 41.77,56.64 ; D5.A 43.01,55.75 ; C71.2 34.52,37.83 ; C71.2 32.91,38.91 ; C71.2 32.91,36.75 ; C71.2 31.46,37.83 ; J3.16 41.62,29.17 ; J3.16 40.6,30.19 ; J3.16 39.59,29.17 ; C70.2 30.18,37.83 ; C70.2 26.95,37.83 ; C70.2 28.56,36.75 ; C70.2 28.56,38.91 ; J20.5 19.06,27.89 ; C14.2 31.97,64.73 ; 43.57,53.55 C32.2 44.34,54.19 ; 19.8,23.21 U23.2 19.8,21.83 ; J3.19 42.13,29.17 ; J3.19 43.14,30.19 ; J3.19 44.16,29.17 ; J20.3 20.33,27.89 ; 18.43,32.43 J15.3 ; 48.09,53.43 C30.2 C26.2 ; C13.2 30.7,64.73 ; C10.2 15.81,68.95 ; C10.2 16.32,69.45 ; C10.2 16.83,68.95
  TOP w0.889: C11.2 27.55,69.37 ; C11.2 26.53,71.33 ; C11.2 26.53,67.4 ; C11.2 25.51,69.37 ; C16.2 39.35,60.84 ; C16.2 41.31,59.83 ; C16.2 39.35,58.81 ; C8.2 44.26,69.4 ; C8.2 45.28,67.43 ; C8.2 44.26,65.47 ; C8.2 43.24,67.43
  L2_GND_1 w0.254: 41.71,5.55 P1.34 ; P1.34 42.89,6.73 ; P1.34 44.07,5.55 ; P1.34 42.89,4.37 ; J11.4 4.66,50.76 ; J11.4 3.64,51.78 ; J11.4 2.63,50.76 ; J11.4 3.64,49.74 ; P1.22 59.31,5.55 ; P1.22 58.13,4.37 ; P1.22 58.13,6.73 ; P1.22 56.95,5.55 ; 22.57,4.37 P1.50 ; P1.50 21.39,5.55 ; P1.50 23.75,5.55 ; P1.50 22.57,6.73 ; 70.83,4.37 P1.12 ; P1.12 70.83,6.73 ; P1.12 72.01,5.55 ; P1.12 69.65,5.55 ; 85.29,26.63 J5.12 ; J5.12 87.35,26.63 ; J5.12 86.32,27.66 ; J5.12 86.32,25.6 ; J9.3 12.29,67.37 ; J9.3 10.38,68.28 ; J9.3 8.46,67.37 ; J9.3 10.38,66.45 ; J13.4 4.66,37.17 ; J13.4 3.64,36.15 ; J13.4 3.64,38.19 ; J13.4 2.63,37.17 ; P1.48 25.11,6.73 ; P1.48 26.29,5.55 ; P1.48 25.11,4.37 ; P1.48 23.93,5.55 ; P1.20 61.85,5.55 ; P1.20 60.67,6.73 ; P1.20 59.49,5.55 ; P1.20 60.67,4.37 ; J3.12 35.52,25.11 ; J3.12 36.54,24.09 ; J3.12 35.52,23.07 ; J3.12 34.51,24.09 ; P1.46 27.65,6.73 ; P1.46 26.47,5.55 ; P1.46 27.65,4.37 ; P1.46 28.83,5.55 ; 3.08,72.55 J9.SH1 ; J9.SH1 1.02,73.47 ; J9.SH1 3.08,74.38 ; J9.SH1 5.13,73.47 ; P1.30 47.97,6.73 ; P1.30 46.79,5.55 ; P1.30 49.15,5.55 ; P1.30 47.97,4.37 ; P1.36 40.35,6.73 ; P1.36 39.17,5.55 ; P1.36 40.35,4.37 ; P1.36 41.53,5.55 ; 37.81,4.37 P1.38 ; P1.38 36.63,5.55 ; P1.38 38.99,5.55 ; P1.38 37.81,6.73 ; P1.2 83.53,6.73 ; P1.2 83.53,4.37 ; P1.2 84.71,5.55 ; P1.2 82.35,5.55 ; 77.27,5.55 P1.6 ; P1.6 78.45,4.37 ; P1.6 79.63,5.55 ; P1.6 78.45,6.73 ; J2.19 27.39,77.43 ; J2.19 26.38,76.41 ; J2.19 26.38,78.45 ; J2.19 25.36,77.43 ; P1.8 77.09,5.55 ; P1.8 75.91,6.73 ; P1.8 75.91,4.37 ; P1.8 74.73,5.55 ; 40.6,23.07 J3.18 ; J3.18 40.6,25.11 ; J3.18 41.62,24.09 ; J3.18 39.59,24.09 ; P1.24 56.77,5.55 ; P1.24 54.41,5.55 ; P1.24 55.59,6.73 ; P1.24 55.59,4.37 ; 53.05,4.37 P1.26 ; P1.26 54.23,5.55 ; P1.26 51.87,5.55 ; P1.26 53.05,6.73 ; J9.SH2 3.08,64.48 ; J9.SH2 5.13,63.57 ; J9.SH2 3.08,62.65 ; J9.SH2 1.02,63.57 ; 63.21,4.37 P1.18 ; P1.18 62.03,5.55 ; P1.18 64.39,5.55 ; P1.18 63.21,6.73 ; J3.16 40.6,30.19 ; J3.16 40.6,28.15 ; J3.16 39.59,29.17 ; J3.16 41.62,29.17 ; J6.17 79.72,79.97 ; J6.17 78.7,80.99 ; J6.17 78.7,78.95 ; J6.17 77.69,79.97 ; 50.51,4.37 P1.28 ; P1.28 51.69,5.55 ; P1.28 50.51,6.73 ; P1.28 49.33,5.55 ; 72.19,5.55 P1.10 ; P1.10 73.37,6.73 ; P1.10 74.55,5.55 ; P1.10 73.37,4.37 ; 32.73,4.37 P1.42 ; P1.42 31.55,5.55 ; P1.42 32.73,6.73 ; P1.42 33.91,5.55 ; 55.84,81.49 J1.12 ; J1.12 56.86,82.51 ; J1.12 54.83,82.51 ; J1.12 55.84,83.53 ; 119.6,48.73 R186.3 ; R186.3 120.61,49.74 ; R186.3 121.63,48.73 ; R186.3 120.61,47.71 ; J1.9 59.4,82.51 ; J1.9 57.37,82.51 ; J1.9 58.38,83.53 ; J1.9 58.38,81.49 ; 67.11,5.55 P1.14 ; P1.14 69.47,5.55 ; P1.14 68.29,6.73 ; P1.14 68.29,4.37 ; 34.09,5.55 P1.40 ; P1.40 36.45,5.55 ; P1.40 35.27,4.37 ; P1.40 35.27,6.73 ; 80.99,4.37 P1.4 ; P1.4 79.81,5.55 ; P1.4 82.17,5.55 ; P1.4 80.99,6.73 ; J9.2 12.29,72.57 ; J9.2 10.38,71.65 ; J9.2 8.46,72.57 ; J9.2 10.38,73.48 ; 45.43,4.37 P1.32 ; P1.32 45.43,6.73 ; P1.32 44.25,5.55 ; P1.32 46.61,5.55 ; P1.16 65.75,6.73 ; P1.16 65.75,4.37 ; P1.16 66.93,5.55 ; P1.16 64.57,5.55 ; J17.4 3.64,24.09 ; J17.4 4.66,23.07 ; J17.4 2.63,23.07 ; J17.4 3.64,22.06 ; P1.44 30.19,6.73 ; P1.44 31.37,5.55 ; P1.44 29.01,5.55 ; P1.44 30.19,4.37 ; 42.13,29.17 J3.19 ; J3.19 43.14,30.19 ; J3.19 44.16,29.17 ; J3.19 43.14,28.15
  L2_GND_1 w0.762: J20.5 19.06,27.89 ; J15.3 18.43,33.01 v1(18.55,33.13) ; J20.3 20.33,27.89
  L3_INT_1 w0.254: 54.83,82.51 J1.12 ; J1.12 55.84,83.53 ; J1.12 55.84,81.49 ; J1.12 56.86,82.51 ; 62.03,5.55 P1.18 ; P1.18 63.21,4.37 ; P1.18 63.21,6.73 ; P1.18 64.39,5.55 ; J13.4 4.66,37.17 ; J13.4 3.64,36.15 ; J13.4 2.63,37.17 ; J13.4 3.64,38.19 ; 39.59,29.17 J3.16 ; J3.16 40.6,30.19 ; J3.16 41.62,29.17 ; 58.38,81.49 J1.9 ; J1.9 59.4,82.51 ; J1.9 57.37,82.51 ; J1.9 58.38,83.53 ; 27.65,4.37 P1.46 ; P1.46 27.65,6.73 ; P1.46 26.47,5.55 ; P1.46 28.83,5.55 ; 79.81,5.55 P1.4 ; P1.4 80.99,4.37 ; P1.4 82.17,5.55 ; P1.4 80.99,6.73 ; P1.24 55.59,6.73 ; P1.24 54.41,5.55 ; P1.24 55.59,4.37 ; P1.24 56.77,5.55 ; P1.30 49.15,5.55 ; P1.30 47.97,4.37 ; P1.30 46.79,5.55 ; P1.30 47.97,6.73 ; P1.44 31.37,5.55 ; P1.44 29.01,5.55 ; P1.44 30.19,6.73 ; P1.44 30.19,4.37 ; P1.2 83.53,6.73 ; P1.2 83.53,4.37 ; P1.2 84.71,5.55 ; P1.2 82.35,5.55 ; J5.12 87.35,26.63 ; J5.12 86.32,27.66 ; J5.12 86.32,25.6 ; J5.12 85.29,26.63 ; J11.4 3.64,51.78 ; J11.4 4.66,50.76 ; J11.4 3.64,49.74 ; J11.4 2.63,50.76 ; 36.63,5.55 P1.38 ; P1.38 37.81,6.73 ; P1.38 37.81,4.37 ; P1.38 38.99,5.55 ; 8.46,72.57 J9.2 ; J9.2 10.38,73.48 ; J9.2 10.38,71.65 ; R186.3 120.61,49.74 ; R186.3 120.61,47.71 ; R186.3 121.63,48.73 ; R186.3 119.6,48.73 ; 35.52,23.07 J3.12 ; J3.12 35.52,25.11 ; J3.12 34.51,24.09 ; P1.42 33.91,5.55 ; P1.42 32.73,4.37 ; P1.42 32.73,6.73 ; P1.42 31.55,5.55 ; 75.91,4.37 P1.8 ; P1.8 75.91,6.73 ; P1.8 77.09,5.55 ; P1.8 74.73,5.55 ; 60.67,4.37 P1.20 ; P1.20 60.67,6.73 ; P1.20 61.85,5.55 ; P1.20 59.49,5.55 ; 53.05,4.37 P1.26 ; P1.26 54.23,5.55 ; P1.26 51.87,5.55 ; P1.26 53.05,6.73 ; J2.19 27.39,77.43 ; J2.19 25.36,77.43 ; J2.19 26.38,76.41 ; 42.89,4.37 P1.34 ; P1.34 44.07,5.55 ; P1.34 42.89,6.73 ; P1.34 41.71,5.55 ; P1.50 22.57,6.73 ; P1.50 23.75,5.55 ; P1.50 21.39,5.55 ; P1.50 22.57,4.37 ; P1.14 68.29,6.73 ; P1.14 67.11,5.55 ; P1.14 68.29,4.37 ; P1.14 69.47,5.55 ; J9.SH1 3.08,74.38 ; J9.SH1 5.13,73.47 ; J9.SH1 3.08,72.55 ; J9.SH1 1.02,73.47 ; J6.17 79.72,79.97 ; J6.17 78.7,78.95 ; J6.17 77.69,79.97 ; J6.17 78.7,80.99 ; P1.22 59.31,5.55 ; P1.22 56.95,5.55 ; P1.22 58.13,4.37 ; P1.22 58.13,6.73 ; P1.6 78.45,6.73 ; P1.6 78.45,4.37 ; P1.6 79.63,5.55 ; P1.6 77.27,5.55 ; P1.10 74.55,5.55 ; P1.10 73.37,6.73 ; P1.10 73.37,4.37 ; P1.10 72.19,5.55 ; 39.59,24.09 J3.18 41.62,24.09 ; 45.43,4.37 P1.32 ; P1.32 45.43,6.73 ; P1.32 46.61,5.55 ; P1.32 44.25,5.55 ; 70.83,4.37 P1.12 ; P1.12 72.01,5.55 ; P1.12 69.65,5.55 ; P1.12 70.83,6.73 ; 23.93,5.55 P1.48 ; P1.48 26.29,5.55 ; P1.48 25.11,4.37 ; P1.48 25.11,6.73 ; P1.28 51.69,5.55 ; P1.28 49.33,5.55 ; P1.28 50.51,4.37 ; P1.28 50.51,6.73 ; 42.13,29.17 J3.19 43.14,30.19 ; P1.40 35.27,6.73 ; P1.40 34.09,5.55 ; P1.40 35.27,4.37 ; P1.40 36.45,5.55 ; J17.4 4.66,23.07 ; J17.4 3.64,24.09 ; J17.4 3.64,22.06 ; J17.4 2.63,23.07 ; P1.36 40.35,6.73 ; P1.36 41.53,5.55 ; P1.36 40.35,4.37 ; P1.36 39.17,5.55 ; J20.3 20.33,27.89 ; J15.3 18.43,32.52 ; J9.SH2 3.08,64.48 ; J9.SH2 1.02,63.57 ; J9.SH2 3.08,62.65 ; J9.SH2 5.13,63.57 ; J20.5 19.06,27.89 ; P1.16 65.75,6.73 ; P1.16 64.57,5.55 ; P1.16 65.75,4.37 ; P1.16 66.93,5.55 ; 10.38,66.45 J9.3 ; J9.3 10.38,68.28 ; J9.3 8.46,67.37
  L4_PWR_1 w0.254: 59.49,5.55 P1.20 ; P1.20 60.67,4.37 ; P1.20 60.67,6.73 ; P1.20 61.85,5.55 ; P1.18 64.39,5.55 ; P1.18 63.21,4.37 ; P1.18 63.21,6.73 ; P1.18 62.03,5.55 ; R186.3 121.63,48.73 ; R186.3 119.6,48.73 ; R186.3 120.61,47.71 ; R186.3 120.61,49.74 ; 31.55,5.55 P1.42 ; P1.42 33.91,5.55 ; P1.42 32.73,4.37 ; P1.42 32.73,6.73 ; 45.43,4.37 P1.32 ; P1.32 45.43,6.73 ; P1.32 44.25,5.55 ; P1.32 46.61,5.55 ; P1.48 25.11,6.73 ; P1.48 26.29,5.55 ; P1.48 25.11,4.37 ; P1.48 23.93,5.55 ; P1.36 40.35,6.73 ; P1.36 39.17,5.55 ; P1.36 40.35,4.37 ; P1.36 41.53,5.55 ; 73.37,4.37 P1.10 ; P1.10 73.37,6.73 ; P1.10 72.19,5.55 ; P1.10 74.55,5.55 ; P1.50 22.57,6.73 ; P1.50 23.75,5.55 ; P1.50 22.57,4.37 ; P1.50 21.39,5.55 ; 54.41,5.55 P1.24 ; P1.24 55.59,6.73 ; P1.24 56.77,5.55 ; P1.24 55.59,4.37 ; 27.65,4.37 P1.46 ; P1.46 27.65,6.73 ; P1.46 28.83,5.55 ; P1.46 26.47,5.55 ; P1.2 83.53,6.73 ; P1.2 82.35,5.55 ; P1.2 83.53,4.37 ; P1.2 84.71,5.55 ; 42.89,4.37 P1.34 ; P1.34 44.07,5.55 ; P1.34 41.71,5.55 ; P1.34 42.89,6.73 ; P1.12 70.83,6.73 ; P1.12 72.01,5.55 ; P1.12 70.83,4.37 ; P1.12 69.65,5.55 ; P1.8 75.91,6.73 ; P1.8 75.91,4.37 ; P1.8 77.09,5.55 ; P1.8 74.73,5.55 ; J1.9 58.38,83.53 ; J1.9 59.4,82.51 ; J1.9 58.38,81.49 ; J1.9 57.37,82.51 ; P1.38 38.99,5.55 ; P1.38 37.81,6.73 ; P1.38 37.81,4.37 ; P1.38 36.63,5.55 ; 54.83,82.51 J1.12 ; J1.12 55.84,83.53 ; J1.12 56.86,82.51 ; J1.12 55.84,81.49 ; 53.05,4.37 P1.26 ; P1.26 54.23,5.55 ; P1.26 53.05,6.73 ; P1.26 51.87,5.55 ; P1.16 66.93,5.55 ; P1.16 64.57,5.55 ; P1.16 65.75,6.73 ; P1.16 65.75,4.37 ; 34.09,5.55 P1.40 ; P1.40 36.45,5.55 ; P1.40 35.27,4.37 ; P1.40 35.27,6.73 ; 78.7,78.95 J6.17 ; J6.17 79.72,79.97 ; J6.17 78.7,80.99 ; J6.17 77.69,79.97 ; P1.30 49.15,5.55 ; P1.30 47.97,4.37 ; P1.30 46.79,5.55 ; P1.30 47.97,6.73 ; 58.13,4.37 P1.22 ; P1.22 56.95,5.55 ; P1.22 58.13,6.73 ; P1.22 59.31,5.55 ; J9.SH1 3.08,74.38 ; P1.28 50.51,6.73 ; P1.28 50.51,4.37 ; P1.28 49.33,5.55 ; P1.28 51.69,5.55 ; 78.45,4.37 P1.6 ; P1.6 79.63,5.55 ; P1.6 77.27,5.55 ; P1.6 78.45,6.73 ; J2.19 27.39,77.43 ; J2.19 26.38,78.45 ; J2.19 25.36,77.43 ; J2.19 26.38,76.41 ; 68.29,4.37 P1.14 ; P1.14 67.11,5.55 ; P1.14 68.29,6.73 ; P1.14 69.47,5.55 ; 80.99,4.37 P1.4 ; P1.4 82.17,5.55 ; P1.4 80.99,6.73 ; P1.4 79.81,5.55 ; 29.01,5.55 P1.44 ; P1.44 30.19,6.73 ; P1.44 31.37,5.55 ; P1.44 30.19,4.37
  L5_PWR_2 w0.254: 3.08,72.55 J9.SH1 ; J9.SH1 3.08,74.38 ; J9.SH1 1.02,73.47 ; J9.SH1 5.13,73.47 ; 42.13,29.17 J3.19 ; J3.19 44.16,29.17 ; J3.19 43.14,30.19 ; J3.19 43.14,28.15 ; P1.2 83.53,6.73 ; P1.2 82.35,5.55 ; P1.2 84.71,5.55 ; P1.2 83.53,4.37 ; 60.67,4.37 P1.20 ; P1.20 61.85,5.55 ; P1.20 60.67,6.73 ; P1.20 59.49,5.55 ; J5.12 86.32,27.66 ; J5.12 87.35,26.63 ; J5.12 86.32,25.6 ; J5.12 85.29,26.63 ; P1.36 40.35,6.73 ; P1.36 41.53,5.55 ; P1.36 40.35,4.37 ; P1.36 39.17,5.55 ; 10.38,71.65 J9.2 ; J9.2 8.46,72.57 ; J9.2 12.29,72.57 ; J9.2 10.38,73.48 ; J1.9 58.38,83.53 ; J1.9 57.37,82.51 ; J1.9 59.4,82.51 ; J1.9 58.38,81.49 ; 3.08,62.65 J9.SH2 ; J9.SH2 1.02,63.57 ; J9.SH2 3.08,64.48 ; J9.SH2 5.13,63.57 ; P1.22 59.31,5.55 ; P1.22 56.95,5.55 ; P1.22 58.13,4.37 ; P1.22 58.13,6.73 ; P1.4 82.17,5.55 ; P1.4 80.99,4.37 ; P1.4 79.81,5.55 ; P1.4 80.99,6.73 ; J3.16 40.6,30.19 ; J3.16 41.62,29.17 ; J3.16 39.59,29.17 ; J3.16 40.6,28.15 ; J3.18 41.62,24.09 ; J3.18 39.59,24.09 ; J3.18 40.6,23.07 ; J3.18 40.6,25.11 ; 69.65,5.55 P1.12 ; P1.12 72.01,5.55 ; P1.12 70.83,4.37 ; P1.12 70.83,6.73 ; P1.26 53.05,6.73 ; P1.26 51.87,5.55 ; P1.26 53.05,4.37 ; P1.26 54.23,5.55 ; 47.97,4.37 P1.30 ; P1.30 46.79,5.55 ; P1.30 47.97,6.73 ; P1.30 49.15,5.55 ; 68.29,4.37 P1.14 ; P1.14 69.47,5.55 ; P1.14 67.11,5.55 ; P1.14 68.29,6.73 ; 27.65,4.37 P1.46 ; P1.46 26.47,5.55 ; P1.46 28.83,5.55 ; P1.46 27.65,6.73 ; P1.42 32.73,6.73 ; P1.42 33.91,5.55 ; P1.42 32.73,4.37 ; P1.42 31.55,5.55 ; 55.59,4.37 P1.24 ; P1.24 56.77,5.55 ; P1.24 55.59,6.73 ; P1.24 54.41,5.55 ; 36.63,5.55 P1.38 ; P1.38 37.81,4.37 ; P1.38 38.99,5.55 ; P1.38 37.81,6.73 ; 65.75,4.37 P1.16 ; P1.16 64.57,5.55 ; P1.16 65.75,6.73 ; P1.16 66.93,5.55 ; J1.12 56.86,82.51 ; J1.12 55.84,81.49 ; J1.12 54.83,82.51 ; J1.12 55.84,83.53 ; J13.4 3.64,38.19 ; J13.4 3.64,36.15 ; J13.4 4.66,37.17 ; 44.25,5.55 P1.32 ; P1.32 45.43,4.37 ; P1.32 45.43,6.73 ; P1.32 46.61,5.55 ; 120.61,47.71 R186.3 ; R186.3 120.61,49.74 ; R186.3 119.6,48.73 ; R186.3 121.63,48.73 ; P1.48 25.11,6.73 ; P1.48 25.11,4.37 ; P1.48 26.29,5.55 ; P1.48 23.93,5.55 ; P1.6 78.45,6.73 ; P1.6 79.63,5.55 ; P1.6 78.45,4.37 ; P1.6 77.27,5.55 ; P1.18 63.21,6.73 ; P1.18 63.21,4.37 ; P1.18 64.39,5.55 ; P1.18 62.03,5.55 ; J6.17 79.72,79.97 ; J6.17 78.7,80.99 ; J6.17 78.7,78.95 ; J6.17 77.69,79.97 ; 10.38,66.45 J9.3 ; J9.3 8.46,67.37 ; J9.3 12.29,67.37 ; J9.3 10.38,68.28 ; P1.10 74.55,5.55 ; P1.10 72.19,5.55 ; P1.10 73.37,6.73 ; P1.10 73.37,4.37 ; P1.40 36.45,5.55 ; P1.40 34.09,5.55 ; P1.40 35.27,6.73 ; P1.40 35.27,4.37 ; P1.44 30.19,6.73 ; P1.44 29.01,5.55 ; P1.44 30.19,4.37 ; P1.44 31.37,5.55 ; 41.71,5.55 P1.34 ; P1.34 42.89,6.73 ; P1.34 44.07,5.55 ; P1.34 42.89,4.37 ; 49.33,5.55 P1.28 ; P1.28 51.69,5.55 ; P1.28 50.51,4.37 ; P1.28 50.51,6.73 ; J11.4 4.66,50.76 ; J11.4 3.64,49.74 ; J11.4 3.64,51.78 ; J2.19 27.39,77.43 ; J2.19 26.38,78.45 ; J2.19 25.36,77.43 ; J20.5 19.06,27.89 ; P1.8 75.91,6.73 ; P1.8 74.73,5.55 ; P1.8 77.09,5.55 ; P1.8 75.91,4.37 ; P1.50 23.75,5.55 ; P1.50 22.57,6.73 ; P1.50 21.39,5.55 ; P1.50 22.57,4.37 ; J20.3 20.33,27.89 ; J15.3 18.43,32.52
  L6_INT_2 w0.254: P1.44 30.19,6.73 ; P1.44 30.19,4.37 ; P1.44 29.01,5.55 ; P1.44 31.37,5.55 ; 46.79,5.55 P1.30 ; P1.30 49.15,5.55 ; P1.30 47.97,6.73 ; P1.30 47.97,4.37 ; P1.48 26.29,5.55 ; P1.48 25.11,6.73 ; P1.48 25.11,4.37 ; P1.48 23.93,5.55 ; J9.2 12.29,72.57 ; J9.2 10.38,71.65 ; J9.2 10.38,73.48 ; J9.2 8.46,72.57 ; 85.29,26.63 J5.12 ; J5.12 86.32,27.66 ; J5.12 86.32,25.6 ; J5.12 87.35,26.63 ; P1.24 56.77,5.55 ; P1.24 55.59,4.37 ; P1.24 55.59,6.73 ; P1.24 54.41,5.55 ; J1.12 55.84,83.53 ; J1.12 54.83,82.51 ; J1.12 56.86,82.51 ; J1.12 55.84,81.49 ; J6.17 79.72,79.97 ; J6.17 78.7,78.95 ; J6.17 77.69,79.97 ; 21.39,5.55 P1.50 ; P1.50 22.57,4.37 ; P1.50 23.75,5.55 ; P1.50 22.57,6.73 ; P1.16 66.93,5.55 ; P1.16 64.57,5.55 ; P1.16 65.75,6.73 ; P1.16 65.75,4.37 ; J17.4 3.64,24.09 ; J17.4 3.64,22.06 ; J17.4 4.66,23.07 ; J17.4 2.63,23.07 ; 35.27,4.37 P1.40 ; P1.40 34.09,5.55 ; P1.40 36.45,5.55 ; P1.40 35.27,6.73 ; P1.10 74.55,5.55 ; P1.10 73.37,6.73 ; P1.10 73.37,4.37 ; P1.10 72.19,5.55 ; P1.34 44.07,5.55 ; P1.34 42.89,6.73 ; P1.34 41.71,5.55 ; P1.34 42.89,4.37 ; 39.17,5.55 P1.36 ; P1.36 40.35,6.73 ; P1.36 40.35,4.37 ; P1.36 41.53,5.55 ; P1.14 68.29,6.73 ; P1.14 67.11,5.55 ; P1.14 68.29,4.37 ; P1.14 69.47,5.55 ; 41.62,24.09 J3.18 40.6,25.11 ; 34.51,24.09 J3.12 ; J3.12 36.54,24.09 ; J3.12 35.52,23.07 ; 70.83,4.37 P1.12 ; P1.12 69.65,5.55 ; P1.12 70.83,6.73 ; P1.12 72.01,5.55 ; J15.3 18.43,32.52 ; P1.42 33.91,5.55 ; P1.42 32.73,4.37 ; P1.42 32.73,6.73 ; P1.42 31.55,5.55 ; 75.91,4.37 P1.8 ; P1.8 74.73,5.55 ; P1.8 75.91,6.73 ; P1.8 77.09,5.55 ; J9.SH2 5.13,63.57 ; J9.SH2 3.08,64.48 ; J9.SH2 3.08,62.65 ; J9.SH2 1.02,63.57 ; P1.20 61.85,5.55 ; P1.20 59.49,5.55 ; P1.20 60.67,6.73 ; P1.20 60.67,4.37 ; 57.37,82.51 J1.9 ; J1.9 58.38,81.49 ; J1.9 58.38,83.53 ; 53.05,4.37 P1.26 ; P1.26 53.05,6.73 ; P1.26 51.87,5.55 ; P1.26 54.23,5.55 ; 39.59,29.17 J3.16 41.62,29.17 ; 80.99,4.37 P1.4 ; P1.4 80.99,6.73 ; P1.4 79.81,5.55 ; P1.4 82.17,5.55 ; 8.46,67.37 J9.3 ; J9.3 12.29,67.37 ; J9.3 10.38,68.28 ; J9.3 10.38,66.45 ; 36.63,5.55 P1.38 ; P1.38 38.99,5.55 ; P1.38 37.81,6.73 ; P1.38 37.81,4.37 ; P1.46 28.83,5.55 ; P1.46 26.47,5.55 ; P1.46 27.65,6.73 ; P1.46 27.65,4.37 ; J2.19 27.39,77.43 ; J2.19 26.38,78.45 ; J2.19 25.36,77.43 ; 2.63,37.17 J13.4 ; J13.4 3.64,38.19 ; J13.4 3.64,36.15 ; J13.4 4.66,37.17 ; 49.33,5.55 P1.28 ; P1.28 50.51,6.73 ; P1.28 51.69,5.55 ; P1.28 50.51,4.37 ; 119.6,48.73 R186.3 ; R186.3 120.61,49.74 ; R186.3 121.63,48.73 ; R186.3 120.61,47.71 ; 3.64,49.74 J11.4 ; J11.4 4.66,50.76 ; J11.4 3.64,51.78 ; J11.4 2.63,50.76 ; P1.2 83.53,6.73 ; P1.2 82.35,5.55 ; P1.2 83.53,4.37 ; P1.2 84.71,5.55 ; P1.22 59.31,5.55 ; P1.22 56.95,5.55 ; P1.22 58.13,6.73 ; P1.22 58.13,4.37 ; 42.13,29.17 J3.19 43.14,28.15 ; P1.18 63.21,6.73 ; P1.18 62.03,5.55 ; P1.18 63.21,4.37 ; P1.18 64.39,5.55 ; P1.32 46.61,5.55 ; P1.32 44.25,5.55 ; P1.32 45.43,4.37 ; P1.32 45.43,6.73 ; P1.6 79.63,5.55 ; P1.6 77.27,5.55 ; P1.6 78.45,4.37 ; P1.6 78.45,6.73 ; J20.3 20.33,27.89 ; J9.SH1 3.08,74.38 ; J9.SH1 5.13,73.47 ; J9.SH1 1.02,73.47 ; J9.SH1 3.08,72.55
  L7_GND_2 w0.254: 53.05,4.37 P1.26 ; P1.26 51.87,5.55 ; P1.26 53.05,6.73 ; P1.26 54.23,5.55 ; 32.73,4.37 P1.42 ; P1.42 31.55,5.55 ; P1.42 33.91,5.55 ; P1.42 32.73,6.73 ; 27.65,4.37 P1.46 ; P1.46 28.83,5.55 ; P1.46 27.65,6.73 ; P1.46 26.47,5.55 ; 42.89,4.37 P1.34 ; P1.34 42.89,6.73 ; P1.34 44.07,5.55 ; P1.34 41.71,5.55 ; J1.12 56.86,82.51 ; J1.12 55.84,81.49 ; J1.12 54.83,82.51 ; J1.12 55.84,83.53 ; J20.5 19.06,27.89 ; R186.3 120.61,49.74 ; R186.3 121.63,48.73 ; R186.3 120.61,47.71 ; R186.3 119.6,48.73 ; 42.13,29.17 J3.19 ; J3.19 43.14,28.15 ; J3.19 43.14,30.19 ; J3.19 44.16,29.17 ; 79.81,5.55 P1.4 ; P1.4 80.99,4.37 ; P1.4 82.17,5.55 ; P1.4 80.99,6.73 ; J9.SH2 3.08,64.48 ; J9.SH2 3.08,62.65 ; J9.SH2 5.13,63.57 ; J9.SH2 1.02,63.57 ; P1.16 65.75,6.73 ; P1.16 64.57,5.55 ; P1.16 65.75,4.37 ; P1.16 66.93,5.55 ; J3.12 35.52,25.11 ; J3.12 35.52,23.07 ; J3.12 34.51,24.09 ; J3.12 36.54,24.09 ; P1.30 49.15,5.55 ; P1.30 46.79,5.55 ; P1.30 47.97,6.73 ; P1.30 47.97,4.37 ; 67.11,5.55 P1.14 ; P1.14 69.47,5.55 ; P1.14 68.29,4.37 ; P1.14 68.29,6.73 ; 44.25,5.55 P1.32 ; P1.32 46.61,5.55 ; P1.32 45.43,4.37 ; P1.32 45.43,6.73 ; 29.01,5.55 P1.44 ; P1.44 31.37,5.55 ; P1.44 30.19,4.37 ; P1.44 30.19,6.73 ; J17.4 3.64,24.09 ; J17.4 3.64,22.06 ; J17.4 2.63,23.07 ; J17.4 4.66,23.07 ; J2.19 26.38,78.45 ; J2.19 27.39,77.43 ; J2.19 25.36,77.43 ; J2.19 26.38,76.41 ; P1.36 40.35,6.73 ; P1.36 40.35,4.37 ; P1.36 41.53,5.55 ; P1.36 39.17,5.55 ; J5.12 86.32,27.66 ; J5.12 86.32,25.6 ; J5.12 87.35,26.63 ; J5.12 85.29,26.63 ; J9.2 12.29,72.57 ; J9.2 10.38,73.48 ; J9.2 8.46,72.57 ; J9.2 10.38,71.65 ; P1.40 35.27,6.73 ; P1.40 36.45,5.55 ; P1.40 35.27,4.37 ; P1.40 34.09,5.55 ; J3.18 41.62,24.09 ; J3.18 40.6,23.07 ; J3.18 39.59,24.09 ; J3.18 40.6,25.11 ; J15.3 18.43,32.52 ; 56.95,5.55 P1.22 ; P1.22 58.13,6.73 ; P1.22 58.13,4.37 ; P1.22 59.31,5.55 ; 78.7,78.95 J6.17 ; J6.17 77.69,79.97 ; J6.17 79.72,79.97 ; J6.17 78.7,80.99 ; 62.03,5.55 P1.18 ; P1.18 64.39,5.55 ; P1.18 63.21,6.73 ; P1.18 63.21,4.37 ; P1.6 79.63,5.55 ; P1.6 78.45,6.73 ; P1.6 78.45,4.37 ; P1.6 77.27,5.55 ; 36.63,5.55 P1.38 ; P1.38 38.99,5.55 ; P1.38 37.81,6.73 ; P1.38 37.81,4.37 ; 83.53,4.37 P1.2 ; P1.2 83.53,6.73 ; P1.2 84.71,5.55 ; P1.2 82.35,5.55 ; J1.9 59.4,82.51 ; J1.9 57.37,82.51 ; J1.9 58.38,83.53 ; J1.9 58.38,81.49 ; 59.49,5.55 P1.20 ; P1.20 60.67,4.37 ; P1.20 61.85,5.55 ; P1.20 60.67,6.73 ; 10.38,66.45 J9.3 ; J9.3 8.46,67.37 ; J9.3 12.29,67.37 ; J9.3 10.38,68.28 ; P1.8 77.09,5.55 ; P1.8 74.73,5.55 ; P1.8 75.91,4.37 ; P1.8 75.91,6.73 ; J9.SH1 5.13,73.47 ; J9.SH1 3.08,74.38 ; J9.SH1 3.08,72.55 ; J9.SH1 1.02,73.47 ; P1.10 73.37,6.73 ; P1.10 72.19,5.55 ; P1.10 73.37,4.37 ; P1.10 74.55,5.55 ; P1.24 56.77,5.55 ; P1.24 54.41,5.55 ; P1.24 55.59,4.37 ; P1.24 55.59,6.73 ; P1.48 25.11,6.73 ; P1.48 26.29,5.55 ; P1.48 23.93,5.55 ; P1.48 25.11,4.37 ; P1.50 23.75,5.55 ; P1.50 22.57,6.73 ; P1.50 22.57,4.37 ; P1.50 21.39,5.55 ; 3.64,36.15 J13.4 ; J13.4 4.66,37.17 ; J13.4 2.63,37.17 ; J13.4 3.64,38.19 ; P1.12 70.83,6.73 ; P1.12 72.01,5.55 ; P1.12 70.83,4.37 ; P1.12 69.65,5.55 ; 3.64,49.74 J11.4 ; J11.4 2.63,50.76 ; J11.4 3.64,51.78 ; J11.4 4.66,50.76 ; 39.59,29.17 J3.16 ; J3.16 40.6,30.19 ; J3.16 41.62,29.17 ; J3.16 40.6,28.15 ; P1.28 50.51,6.73 ; P1.28 50.51,4.37 ; P1.28 49.33,5.55 ; P1.28 51.69,5.55 ; J20.3 20.33,27.89
  BOTTOM w0.203: 75.15,52.23 75.15,52.34 ; 74.38,60.92 C504.2 ; 70.83,60.28 70.83,60.44 ; C506.2 71.34,60.79 ; 61.68,56.09 C516.2
  BOTTOM w0.254: 2.63,50.76 J11.4 ; J11.4 3.64,51.78 ; J11.4 4.66,50.76 ; J11.4 3.64,49.74 ; 3.08,62.65 J9.SH2 ; J9.SH2 3.08,64.48 ; J9.SH2 5.13,63.57 ; J9.SH2 1.02,63.57 ; J3.16 41.62,29.17 ; J3.16 39.59,29.17 ; J3.16 40.6,30.19 ; 23.3,23.28 R608.2 ; R608.2 23.3,24.29 ; R608.2 22.8,23.78 ; 44.25,5.55 P1.32 ; P1.32 45.43,4.37 ; P1.32 45.43,6.73 ; P1.32 46.61,5.55 ; 83.53,4.37 P1.2 ; P1.2 83.53,6.73 ; P1.2 82.35,5.55 ; P1.2 84.71,5.55 ; P1.14 68.29,6.73 ; P1.14 68.29,4.37 ; P1.14 69.47,5.55 ; P1.14 67.11,5.55 ; 40.35,4.37 P1.36 ; P1.36 39.17,5.55 ; P1.36 40.35,6.73 ; P1.36 41.53,5.55 ; 103.95,52.13 103.95,52.23 ; P1.4 80.99,6.73 ; P1.4 79.81,5.55 ; P1.4 82.17,5.55 ; P1.4 80.99,4.37 ; 24.47,19.19 24.47,19.06 ; 73.37,4.37 P1.10 ; P1.10 73.37,6.73 ; P1.10 74.55,5.55 ; P1.10 72.19,5.55 ; Y501.2 22.57,21.49 ; Y501.2 23.81,21.09 ; Y501.2 21.32,21.09 ; Y501.2 22.57,20.7 ; 24.47,57.34 C515.2 ; C515.2 24.98,57.85 ; C515.2 24.47,58.35 ; J9.SH1 5.13,73.47 ; J9.SH1 3.08,72.55 ; J9.SH1 3.08,74.38 ; J9.SH1 1.02,73.47 ; 46.24,70.19 C501.2 ; C501.2 47,69.56 ; C501.2 47.77,70.19 ; 3.64,36.15 J13.4 ; J13.4 2.63,37.17 ; J13.4 4.66,37.17 ; J13.4 3.64,38.19 ; 53.05,4.37 P1.26 ; P1.26 54.23,5.55 ; P1.26 51.87,5.55 ; P1.26 53.05,6.73 ; 21.39,5.55 P1.50 ; P1.50 23.75,5.55 ; P1.50 22.57,4.37 ; P1.50 22.57,6.73 ; J3.12 36.54,24.09 ; J3.12 34.51,24.09 ; J3.12 35.52,23.07 ; 27.65,4.37 P1.46 ; P1.46 26.47,5.55 ; P1.46 27.65,6.73 ; P1.46 28.83,5.55 ; 14.54,15.65 U510.2 15.63,15.65 ; 86.32,27.66 J5.12 86.32,25.6 ; J2.19 26.38,78.45 ; J2.19 26.38,76.41 ; J2.19 27.39,77.43 ; P1.8 75.91,6.73 ; P1.8 77.09,5.55 ; P1.8 75.91,4.37 ; P1.8 74.73,5.55 ; P1.40 35.27,6.73 ; P1.40 34.09,5.55 ; P1.40 35.27,4.37 ; P1.40 36.45,5.55 ; 40.6,23.07 J3.18 ; J3.18 41.62,24.09 ; J3.18 39.59,24.09 ; 8.46,67.37 J9.3 ; J9.3 10.38,66.45 ; J9.3 12.29,67.37 ; J9.3 10.38,68.28 ; 28.39,58.45 U501.4 28.1,59 ; 8.46,72.57 J9.2 ; J9.2 12.29,72.57 ; J9.2 10.38,73.48 ; J9.2 10.38,71.65 ; Q501.2 15.34,76.83 ; Q501.2 14.32,76.83 ; Q501.2 14.83,77.26 ; Q501.2 14.83,76.4 ; 33.94,18.95 U509.4 34.49,19.25 ; 46.79,5.55 P1.30 ; P1.30 49.15,5.55 ; P1.30 47.97,4.37 ; P1.30 47.97,6.73 ; P1.22 58.13,6.73 ; P1.22 58.13,4.37 ; P1.22 59.31,5.55 ; P1.22 56.95,5.55 ; 24.93,54.04 C522.2 25.44,53.53 ; 33,51.48 U506.4 33.29,50.93 ; P1.48 26.29,5.55 ; P1.48 23.93,5.55 ; P1.48 25.11,4.37 ; P1.48 25.11,6.73 ; P1.24 55.59,6.73 ; P1.24 54.41,5.55 ; P1.24 55.59,4.37 ; P1.24 56.77,5.55 ; 41.11,17.28 C543.2 ; C543.2 42.13,17.28 ; C543.2 41.62,17.79 ; 24.47,61.56 C512.2 24.98,61.05 ; C520.2 24.93,55.13 ; C520.2 25.44,54.62 ; C520.2 24.93,54.11 ; 70.98,70.75 C502.2 72,70.75 ; 23.84,13.6 24.08,13.6 ; 37.81,4.37 P1.38 ; P1.38 37.81,6.73 ; P1.38 38.99,5.55 ; P1.38 36.63,5.55 ; P1.28 50.51,6.73 ; P1.28 50.51,4.37 ; P1.28 49.33,5.55 ; P1.28 51.69,5.55 ; P1.12 72.01,5.55 ; P1.12 69.65,5.55 ; P1.12 70.83,4.37 ; P1.12 70.83,6.73 ; J1.12 56.86,82.51 ; J1.12 55.84,83.53 ; J1.12 54.83,82.51 ; J1.12 55.84,81.49 ; P1.34 44.07,5.55 ; P1.34 42.89,6.73 ; P1.34 42.89,4.37 ; P1.34 41.71,5.55 ; 31.66,17.54 31.52,17.54 ; P1.18 64.39,5.55 ; P1.18 63.21,4.37 ; P1.18 63.21,6.73 ; P1.18 62.03,5.55 ; 5.5,18.76 L501.2 ; L501.2 6.49,18.76 ; L501.2 6,19.35 ; L501.2 6,18.16 ; 23.04,12.39 U513.3 23.46,12.72 ; 18.43,32.52 18.43,32.43 ; 119.6,48.73 R186.3 ; R186.3 121.63,48.73 ; R186.3 120.61,49.74 ; R186.3 120.61,47.71 ; J3.19 44.16,29.17 ; J3.19 43.14,30.19 ; J3.19 42.13,29.17 ; 65.75,4.37 P1.16 ; P1.16 64.57,5.55 ; P1.16 65.75,6.73 ; P1.16 66.93,5.55 ; J1.9 58.38,83.53 ; J1.9 59.4,82.51 ; J1.9 57.37,82.51 ; 78.45,4.37 P1.6 ; P1.6 77.27,5.55 ; P1.6 78.45,6.73 ; P1.6 79.63,5.55 ; 22.44,12.2 U513.4 ; 39.59,16.52 C544.2 39.08,16.01 ; 78.7,78.95 J6.17 78.7,80.99 ; C547.2 118.71,78.45 ; C547.2 119.22,77.94 ; C547.2 118.2,77.94 ; 39.59,17.54 C542.2 39.08,18.04 ; P1.20 60.67,6.73 ; P1.20 59.49,5.55 ; P1.20 61.85,5.55 ; P1.20 60.67,4.37 ; 2.63,23.07 J17.4 ; J17.4 3.64,24.09 ; J17.4 3.64,22.06 ; J17.4 4.66,23.07 ; U514.2 17.89,12.65 ; 25.25,65.16 U500.4 25.55,64.62 ; P1.44 30.19,6.73 ; P1.44 29.01,5.55 ; P1.44 30.19,4.37 ; P1.44 31.37,5.55 ; 32.73,4.37 P1.42 ; P1.42 32.73,6.73 ; P1.42 31.55,5.55 ; P1.42 33.91,5.55 ; U511.2 31.71,15.06 ; 15.63,18.65 U510.8 15.09,18.98 ; 11.14,19.69 C536.2 ; 24.98,58.99 C514.2 24.47,58.48 ; 85.13,63.13 C503.2 85.13,62.11 ; 33.62,12.71 R623.2 33.11,12.2 ; 14.41,22.77 14.41,22.61 ; 26.27,48.81 U507.4 26.56,48.27 ; C538.2 11.65,19.7 ; 100.48,53.01 U505.4 100.18,53.56 ; C513.2 24.98,59.98 ; 33.31,57.12 U503.4 ; U512.2 27.14,14.93 ; U504.4 21.49,56.61 ; 16.73,59.51 U502.4 16.44,60.06 ; 23.94,20.84 24.07,20.84 ; 23.84,21.8 24.16,21.8
  BOTTOM w0.279: U515.2 v1(10.68,11.57)
  BOTTOM w0.508: C527.2 47.03,45.3 ; C527.2 46.27,45.93 ; C527.2 45.5,45.3 ; 7.34,79.06 Q500.2 ; Q500.2 7.71,78.56 ; Q500.2 6.81,78.56 ; C530.2 50.18,40.45 ; C530.2 50.81,41.21 ; C530.2 50.18,41.97 ; 22.82,42.76 C529.2 22.19,42 ; C532.2 22.19,38.82 ; C532.2 C531.2 22.19,40.47 ; C532.2 22.82,38.06
  BOTTOM w0.635: 31.52,17.54 C539.2 31.15,17.03 ; 25.26,12.15 R626.2 25.77,11.64 ; 24.35,14.11 C546.2 24.08,13.6 ; C533.2 23.58,28.41 ; C533.2 24.6,28.41 ; C533.2 24.09,28.92 ; 18.81,8.72 R630.2 19.32,9.23 ; C518.2 62.32,56.09 ; C518.2 62.32,54.57 ; C518.2 62.95,55.33 ; C538.2 11.14,19.19 ; C535.2 13.91,22.26 ; C535.2 14.41,22.61 ; C535.2 14.41,21.79 ; 33.82,35.52 U508.4 ; U508.4 32.61,35.01 ; U508.4 35.03,35.01 ; C505.2 62.32,60.92 ; C505.2 61.81,60.41 ; C505.2 61.3,60.92 ; 11.14,21.22 C536.2 10.5,20.46 ; 10.76,17.92 C541.2 11.39,17.15 ; 61.68,57.11 C516.2 62.19,56.6 ; 24.98,18.68 R612.2 24.47,19.06 ; J20.3 20.33,27.89 ; C545.2 12.03,13.8 ; C545.2 11.52,14.31 ; C545.2 12.03,14.82 ; C27.2 96.74,57.11 ; C27.2 97.5,56.47 ; C27.2 95.97,56.47 ; 24.85,21.8 C534.2 24.16,21.8 ; 24.96,20.84 C537.2 24.07,20.84 ; C500.2 105.46,78.5 ; C500.2 104.86,79.18 ; C500.2 104.27,78.5 ; C526.2 31.18,43.77 ; C526.2 31.69,44.28 ; C526.2 30.68,44.28 ; 70.83,60.44 C506.2 ; Y500.2 105.89,69.3 ; Y500.2 104.69,68.41 ; Y500.2 104.69,70.19 ; 67.78,60.28 C509.2 67.27,60.79 ; C525.2 68.3,46.31 ; C525.2 68.8,46.81 ; C525.2 69.3,46.31 ; 14.03,10.88 R629.2 14.54,10.37 ; 29.63,17.54 C540.2 30.14,17.03 ; 74.89,60.41 C504.2 75.4,60.92 ; 75.15,52.34 C524.2 74.64,52.74 ; R500.2 4.32,77.26 ; R500.2 4.91,76.58 ; R500.2 5.51,77.26 ; 18.43,32.43 J15.3 ; 28.13,53.81 C521.2 27.62,53.2 ; C507.2 69.81,60.28 ; 11.14,77.66 R503.2 10.63,77.15 ; C528.2 30.68,43.37 ; C528.2 28.78,43.37 ; C528.2 29.73,42.73 ; C523.2 103.95,53.66 ; C523.2 103.95,52.23 ; C523.2 104.59,52.89 ; 73.62,59.65 C510.2 74.38,60.28 ; R502.2 6.82,77.56 ; 33.11,13.16 R623.2 ; 72.1,59.65 C511.2 71.4,60.28 ; C508.2 68.8,60.28 ; C519.2 28.26,54.75 ; J20.5 19.06,27.89
  vias: v1(1.23,40.37) v1(1.26,23.15) v1(1.33,54.44) v1(1.33,33.64) v1(1.44,28.38) v1(1.59,47.15) v1(3.04,70.93) v1(3.04,60.54) v1(6.08,40.78) v1(6.24,9.08) v1(6.59,59.78) v1(7.05,13.62) v1(7.23,2.47) v1(7.84,70.55) v1(8.19,48.17) v1(8.72,59.93) v1(9.11,54.75) v1(10.25,22.4) v1(12.08,10.15) v1(12.18,13.12) v1(13.12,70.24) v1(13.5,23.78) v1(14.26,27.87) v1(15.99,75.73) v1(16.88,39.69) v1(16.9,17.46) v1(16.93,16.32) v1(17.08,34.73) v1(17.39,6.84) v1(17.64,70.59) v1(17.79,29.14) v1(17.89,67.75) v1(18.07,17.49) v1(18.05,16.34) v1(18.53,4.02) v1(18.68,51.75) v1(19.42,2.75) v1(19.9,14.57) v1(20.66,53.78) v1(20.66,51.78) v1(20.66,49.67) v1(22.72,51.75) v1(22.9,29.2) v1(25.01,2.75) v1(27.62,18.4) v1(30.24,60.46) v1(30.42,69.05) v1(30.82,38.24) v1(30.98,37.12) v1(33.11,2.75) v1(36.06,12.43) v1(36.81,69.72) v1(36.92,57.57) v1(40.2,70.37) v1(40.35,66) v1(40.81,2.6) v1(40.96,61.58) v1(41.06,56.75) v1(42.28,45.98) v1(43.45,59.47) v1(45.96,70.98) v1(48.15,2.55) v1(56.25,30.74) v1(56.38,2.65) v1(61.61,59.32) v1(62.88,16.67) v1(63.46,52.23) v1(64.15,58.89) v1(64.55,55.48) v1(64.94,33.54) v1(65.52,2.7) v1(65.93,60.28) v1(66.43,49.46) v1(66.69,59.07) v1(67.02,55.59) v1(67.7,75.5) v1(68.31,59.17) v1(69,53.07) v1(69.05,15.83) v1(69.48,47.03) v1(69.58,55.48) v1(69.94,58.56) v1(70.29,62.72) v1(71.97,55.64) v1(72.02,53.12) v1(72.3,18.48) v1(72.56,47.58) v1(73.01,25.23) v1(74.31,2.96) v1(74.76,47.64) v1(76.34,60.16) v1(76.44,35.21) v1(76.67,22.95) v1(81.8,39.51) v1(83.91,35.28) v1(83.93,72.45) v1(86.04,72.38) v1(87.39,3.11) v1(87.46,6.44) v1(89.42,55.97) v1(91.4,30.9) v1(91.4,23) v1(92.21,16.7) v1(92.57,70.27) v1(93.51,75.04) v1(93.43,59.37) v1(94.4,34.63) v1(96.33,18.1) v1(97.22,65.82) v1(98.44,22.01) v1(98.69,37.78) v1(98.89,34.25) v1(100.29,34.5) v1(102.63,35.6) v1(107.23,81.7) v1(107.3,71.44) v1(108.09,51.95) v1(109.21,45.84) v1(109.56,57.67) v1(109.72,3.85) v1(109.94,22.11) v1(111.8,54.75) v1(112.86,69.23) v1(113.78,58.68) v1(114.03,80.1) v1(114.69,75.65) v1(114.95,63.21) v1(115.15,22.11) v1(115.28,45.27) v1(115.68,4.18) v1(115.86,60.23) v1(115.94,78.55) v1(117.49,48.02) v1(118.71,49.57) v1(118.76,55.38) v1(118.83,52.51) v1(120.76,45.3) v1(121.04,4.23) v1(122.11,22.06) v1(122.34,61.73) v1(122.85,72.58) v1(123.41,55.81) v1(123.41,51.24) v1(123.46,46.75)
